$ Spice netlist generated by v2lvs
$ v2012.3_31.26    Wed Oct 3 10:58:10 PDT 2012

.SUBCKT system clk rst start motor_done nvm_input_address[11]
+ nvm_input_address[10] nvm_input_address[9] nvm_input_address[8]
+ nvm_input_address[7] nvm_input_address[6] nvm_input_address[5]
+ nvm_input_address[4] nvm_input_address[3] nvm_input_address[2]
+ nvm_input_address[1] nvm_input_address[0] zero one done motor_move
+ motor_direction[0]
Xcamera_module_algo_module_direc_reg_reg_q_0 dff $PINS Q=motor_direction[0]
+ QB=#dummy[0] D=nx22543 CLK=clk
Xix22544 mux21_ni $PINS Y=nx22543 A0=motor_direction[0] A1=nx27166 S0=nx27156
Xix1134 oai21 $PINS Y=nx1133 A0=nx35686 A1=nx34038 B0=nx34027
Xcamera_module_algo_module_modCU_reg_current_state_0 dff $PINS
+ Q=camera_module_algo_module_regs_rst QB=#dummy[1] D=nx1133 CLK=clk
Xix1222 nor03_2x $PINS Y=nx1221 A0=nx22568 A1=rst A2=nx33608
Xix22569 nand03 $PINS Y=nx22568 A0=nx512 A1=nx23021 A2=nx622
Xix513 nor03_2x $PINS Y=nx512 A0=camera_module_algo_module_address_value_1
+ A1=camera_module_algo_module_address_value_3
+ A2=camera_module_algo_module_address_value_2
Xix1154 mux21_ni $PINS Y=nx1153 A0=nx448
+ A1=camera_module_algo_module_address_value_1 S0=nx22973
Xix449 oai32 $PINS Y=nx448 A0=nx22575 A1=nx34138
+ A2=camera_module_algo_module_prev_cont_enable B0=nx35684 B1=nx35796
Xix22576 xnor2 $PINS Y=nx22575 A0=nx22577 A1=nx22931
Xix22578 mux21_ni $PINS Y=nx22577 A0=nx37094 A1=nx23021 S0=one
Xix1074 oai21 $PINS Y=nx1073 A0=nx22585 A1=nx34036 B0=nx22587
Xcamera_module_algo_module_modCU_reg_current_state_6 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_6 QB=nx22585 D=nx1073 CLK=clk
Xix1064 oai22 $PINS Y=nx1063 A0=nx22595 A1=nx34036 B0=rst B1=nx22597
Xcamera_module_algo_module_modCU_reg_current_state_5 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_5 QB=nx22595 D=nx1063 CLK=clk
Xix1054 oai22 $PINS Y=nx1053 A0=nx22597 A1=nx34036 B0=rst B1=nx22601
Xix309 nor02_2x $PINS Y=nx308 A0=rst A1=nx22605
Xix22606 aoi22 $PINS Y=nx22605 A0=camera_module_algo_module_nvm_address_enable
+ A1=camera_module_ack_from_DMA
+ B0=camera_module_algo_module_modCU_current_state_12 B1=nx22568
Xix954 oai22 $PINS Y=nx953 A0=nx22611 A1=nx34036 B0=rst B1=nx22613
Xcamera_module_algo_module_modCU_reg_current_state_2 dff $PINS
+ Q=camera_module_algo_module_nvm_address_enable QB=nx22611 D=nx953 CLK=clk
Xix22614 aoi21 $PINS Y=nx22613 A0=start
+ A1=camera_module_algo_module_modCU_current_state_1
+ B0=camera_module_algo_module_prev_cont_enable
Xcamera_module_algo_module_modCU_reg_current_state_1 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_1 QB=#dummy[2] D=nx22523
+ CLK=clk
Xcamera_module_algo_module_modCU_reg_current_state_13 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_13 QB=nx22565 D=nx1221 CLK=clk
Xcamera_module_algo_module_modCU_reg_current_state_14 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_14 QB=#dummy[3] D=nx22481
+ CLK=clk
Xix22482 nor03_2x $PINS Y=nx22481 A0=nx22627 A1=rst A2=nx22565
Xix22628 xnor2 $PINS Y=nx22627 A0=nx26956 A1=nx27038
Xix26957 oai22 $PINS Y=nx26956 A0=nx22631 A1=nx33816 B0=nx33810
+ B1=camera_module_algo_module_prev_cont_value_15
Xcamera_module_algo_module_curr_cont_reg_reg_q_15 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_15 QB=nx33810 D=nx22273 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_15 dff $PINS
+ Q=camera_module_algo_module_Addout_value_15 QB=#dummy[4] D=nx22263 CLK=clk
Xix26545 xnor2 $PINS Y=nx26544 A0=nx26504 A1=nx33790
Xix26505 oai22 $PINS Y=nx26504 A0=nx22645 A1=nx33765 B0=nx33779 B1=nx33776
Xix22646 aoi22 $PINS Y=nx22645 A0=camera_module_algo_module_diff_value_13
+ A1=camera_module_algo_module_current_cont_value_13 B0=nx26356 B1=nx933
Xcamera_module_algo_module_diff_reg_reg_q_13 dff $PINS
+ Q=camera_module_algo_module_diff_value_13 QB=nx22651 D=nx22213 CLK=clk
Xix22654 aoi21 $PINS Y=nx22653 A0=zero A1=nx34118 B0=nx26412
Xix26413 nor03_2x $PINS Y=nx26412 A0=nx34118 A1=nx35700 A2=nx33384
Xix1254 mux21_ni $PINS Y=nx1253 A0=zero
+ A1=camera_module_algo_module_pixel_value_8 S0=nx37152
Xcamera_module_algo_module_pixel_reg_reg_q_8 dff $PINS
+ Q=camera_module_algo_module_pixel_value_8 QB=#dummy[5] D=nx1253 CLK=clk
Xcamera_module_algo_module_modCU_reg_current_state_3 dff $PINS
+ Q=camera_module_algo_module_pixel_enable QB=nx22601 D=nx1043 CLK=clk
Xix22670 aoi21 $PINS Y=nx22669 A0=nx37086 A1=nx25422 B0=nx704
Xix25423 oai21 $PINS Y=nx25422 A0=nx35708 A1=nx22681 B0=nx22679
Xix22678 oai21 $PINS Y=nx22677 A0=camera_module_algo_module_pixel_value_8
+ A1=nx35670 B0=nx22679
Xix22680 nand02 $PINS Y=nx22679 A0=nx35670
+ A1=camera_module_algo_module_pixel_value_8
Xix22682 aoi21 $PINS Y=nx22681 A0=nx37086 A1=nx25414 B0=nx704
Xix25415 oai21 $PINS Y=nx25414 A0=nx35708 A1=nx22685 B0=nx22679
Xix22686 aoi21 $PINS Y=nx22685 A0=nx37086 A1=nx25406 B0=nx704
Xix25407 oai21 $PINS Y=nx25406 A0=nx35708 A1=nx22689 B0=nx22679
Xix22690 aoi21 $PINS Y=nx22689 A0=nx25398 A1=nx37086 B0=nx704
Xix25399 oai22 $PINS Y=nx25398 A0=nx22693 A1=nx32243 B0=nx33382 B1=nx25374
Xix22694 aoi22 $PINS Y=nx22693 A0=camera_module_algo_module_pixel_value_6
+ A1=nx22699 B0=nx19850 B1=nx22616
Xcamera_module_algo_module_pixel_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_pixel_value_6 QB=#dummy[6] D=nx19243 CLK=clk
Xix19244 mux21_ni $PINS Y=nx19243 A0=nx22608
+ A1=camera_module_algo_module_pixel_value_6 S0=nx37152
Xix22700 mux21_ni $PINS Y=nx22699 A0=nx22701 A1=nx35674 S0=nx36792
Xix22702 nor04 $PINS Y=nx22701 A0=nx22588 A1=nx21934 A2=nx21278 A3=nx20624
Xix22589 nand04 $PINS Y=nx22588 A0=nx22705 A1=nx23302 A2=nx23413 A3=nx23520
Xix22706 oai21 $PINS Y=nx22705 A0=nx22578 A1=nx22500 B0=nx36448
Xix22579 nand04 $PINS Y=nx22578 A0=nx22709 A1=nx23138 A2=nx23165 A3=nx23189
Xix22710 aoi22 $PINS Y=nx22709 A0=camera_module_cache_ram_0__6 A1=nx37030
+ B0=camera_module_cache_ram_16__6 B1=nx37032
Xcamera_module_cache_reg_ram_0__6 dffr $PINS Q=camera_module_cache_ram_0__6
+ QB=#dummy[7] D=nx19233 CLK=clk R=rst
Xix19234 mux21_ni $PINS Y=nx19233 A0=camera_module_cache_ram_0__6 A1=nx35520
+ S0=nx35134
Xix19971 oai221 $PINS Y=nx19970 A0=nx34072 A1=nx22851 B0=nx22871 B1=nx35712
+ C0=nx22874
Xix994 oai32 $PINS Y=nx993 A0=nx22719 A1=nx34070 A2=nx34042 B0=nx22846
+ B1=nx22779
Xcamera_module_DMA_module_R_Cache_addr_reg_q_3 dff $PINS Q=#dummy[8] QB=nx22719
+ D=nx993 CLK=clk
Xcamera_module_DMA_module_controlUnit_reg_state_0 dff $PINS
+ Q=camera_module_DMA_module_signals_1 QB=#dummy[9] D=nx20 CLK=clk
Xcamera_module_DMA_module_controlUnit_reg_state_5 dff $PINS
+ Q=camera_module_ack_from_DMA QB=nx22844 D=nx294 CLK=clk
Xix295 nor03_2x $PINS Y=nx294 A0=nx22727 A1=rst A2=nx22795
Xix22728 nand04 $PINS Y=nx22727 A0=camera_module_cache_address_from_DMA_7
+ A1=camera_module_cache_address_from_DMA_6
+ A2=camera_module_cache_address_from_DMA_5
+ A3=camera_module_cache_address_from_DMA_4
Xcamera_module_DMA_module_R_Cache_addr_reg_q_7 dff $PINS
+ Q=camera_module_cache_address_from_DMA_7 QB=#dummy[10] D=nx1033 CLK=clk
Xix1034 mux21_ni $PINS Y=nx1033 A0=nx276
+ A1=camera_module_cache_address_from_DMA_7 S0=nx22779
Xix269 xnor2 $PINS Y=nx268 A0=nx264 A1=nx22841
Xix265 oai22 $PINS Y=nx264 A0=nx22739 A1=nx22831 B0=nx35672 B1=nx22835
Xix22740 aoi22 $PINS Y=nx22739 A0=zero
+ A1=camera_module_cache_address_from_DMA_5 B0=nx216 B1=nx897
Xcamera_module_DMA_module_R_Cache_addr_reg_q_5 dff $PINS
+ Q=camera_module_cache_address_from_DMA_5 QB=#dummy[11] D=nx1013 CLK=clk
Xix1014 mux21_ni $PINS Y=nx1013 A0=nx226
+ A1=camera_module_cache_address_from_DMA_5 S0=nx37154
Xix219 xnor2 $PINS Y=nx218 A0=nx216 A1=nx22827
Xix217 oai22 $PINS Y=nx216 A0=nx22749 A1=nx22815 B0=nx35672 B1=nx22821
Xix22750 aoi22 $PINS Y=nx22749 A0=zero A1=nx34072 B0=nx126 B1=nx128
Xix127 oai22 $PINS Y=nx126 A0=nx22753 A1=nx22777 B0=nx35670 B1=nx37106
Xix22754 aoi22 $PINS Y=nx22753 A0=zero A1=nx34098 B0=nx78 B1=nx889
Xix974 oai32 $PINS Y=nx973 A0=nx37096 A1=nx34066 A2=nx34040 B0=nx22805
+ B1=nx37154
Xcamera_module_DMA_module_R_Cache_addr_reg_q_1 dff $PINS Q=#dummy[12]
+ QB=nx22757 D=nx973 CLK=clk
Xix179 nor02_2x $PINS Y=nx178 A0=rst A1=nx22761
Xix22762 aoi221 $PINS Y=nx22761 A0=camera_module_DMA_module_controlUnit_state_4
+ A1=nx22727 B0=nx34040 B1=nx35712 C0=camera_module_DMA_module_signals_4
Xcamera_module_DMA_module_controlUnit_reg_state_4 dff $PINS
+ Q=camera_module_DMA_module_controlUnit_state_4 QB=nx22795 D=nx160 CLK=clk
Xix161 nor03_2x $PINS Y=nx160 A0=nx35712 A1=rst A2=nx37028
Xix984 oai32 $PINS Y=nx983 A0=nx37106 A1=nx34066 A2=nx34040 B0=nx22773
+ B1=nx37154
Xcamera_module_DMA_module_R_Cache_addr_reg_q_2 dff $PINS Q=#dummy[13]
+ QB=nx22771 D=nx983 CLK=clk
Xix22776 xnor2 $PINS Y=nx22775 A0=nx22753 A1=nx22777
Xix964 oai32 $PINS Y=nx963 A0=nx37156 A1=nx34066 A2=nx34040 B0=nx22787
+ B1=nx37154
Xcamera_module_DMA_module_R_Cache_addr_reg_q_0 dff $PINS
+ Q=camera_module_cache_address_from_DMA_0 QB=#dummy[14] D=nx963 CLK=clk
Xix57 xnor2 $PINS Y=nx56 A0=one A1=nx22791
Xcamera_module_DMA_module_controlUnit_reg_state_3 dff $PINS
+ Q=camera_module_write_from_DMA QB=#dummy[15] D=nx178 CLK=clk
Xcamera_module_DMA_module_controlUnit_reg_state_2 dff $PINS
+ Q=camera_module_DMA_module_signals_4 QB=#dummy[16] D=nx48 CLK=clk
Xcamera_module_DMA_module_controlUnit_reg_state_1 dff $PINS
+ Q=camera_module_DMA_module_controlUnit_state_1 QB=#dummy[17] D=nx36 CLK=clk
Xix37 nor02_2x $PINS Y=nx36 A0=rst A1=nx22801
Xix22802 aoi21 $PINS Y=nx22801 A0=nx22611
+ A1=camera_module_DMA_module_controlUnit_state_1 B0=nx34066
Xix81 xnor2 $PINS Y=nx80 A0=nx78 A1=nx22811
Xix1004 oai32 $PINS Y=nx1003 A0=nx22821 A1=nx34068 A2=nx34040 B0=nx22823
+ B1=nx37154
Xcamera_module_DMA_module_R_Cache_addr_reg_q_4 dff $PINS
+ Q=camera_module_cache_address_from_DMA_4 QB=nx22821 D=nx1003 CLK=clk
Xix22826 xnor2 $PINS Y=nx22825 A0=nx22749 A1=nx22815
Xix22828 xnor2 $PINS Y=nx22827 A0=camera_module_cache_address_from_DMA_5
+ A1=zero
Xix1024 oai32 $PINS Y=nx1023 A0=nx22835 A1=nx34068 A2=nx34040 B0=nx22837
+ B1=nx37154
Xcamera_module_DMA_module_R_Cache_addr_reg_q_6 dff $PINS
+ Q=camera_module_cache_address_from_DMA_6 QB=nx22835 D=nx1023 CLK=clk
Xix22840 xnor2 $PINS Y=nx22839 A0=nx22739 A1=nx22831
Xix22842 xnor2 $PINS Y=nx22841 A0=camera_module_cache_address_from_DMA_7
+ A1=zero
Xix131 xnor2 $PINS Y=nx130 A0=nx126 A1=nx22849
Xnvm_module_tri_dataout_126 tri01 $PINS Y=nvm_data_126 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_118 tri01 $PINS Y=nvm_data_118 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_110 tri01 $PINS Y=nvm_data_110 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_102 tri01 $PINS Y=nvm_data_102 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_94 tri01 $PINS Y=nvm_data_94 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_86 tri01 $PINS Y=nvm_data_86 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_78 tri01 $PINS Y=nvm_data_78 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_70 tri01 $PINS Y=nvm_data_70 A=nx22549
+ E=nvm_module_GND0
Xix22872 inv01 $PINS Y=nx22871 A=nvm_data_6
Xnvm_module_tri_dataout_6 tri01 $PINS Y=nvm_data_6 A=nx22549 E=nvm_module_GND0
Xix22875 nand02 $PINS Y=nx22874 A0=nx34072 A1=nx19904
Xnvm_module_tri_dataout_62 tri01 $PINS Y=nvm_data_62 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_54 tri01 $PINS Y=nvm_data_54 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_46 tri01 $PINS Y=nvm_data_46 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_38 tri01 $PINS Y=nvm_data_38 A=nx22549
+ E=nvm_module_GND0
Xix19873 oai22 $PINS Y=nx19872 A0=nx34098 A1=nx22887 B0=nx34080 B1=nx22891
Xnvm_module_tri_dataout_30 tri01 $PINS Y=nvm_data_30 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_22 tri01 $PINS Y=nvm_data_22 A=nx22549
+ E=nvm_module_GND0
Xix22892 nand02 $PINS Y=nx22891 A0=nvm_data_14 A1=nx34100
Xnvm_module_tri_dataout_14 tri01 $PINS Y=nvm_data_14 A=nx22549
+ E=nvm_module_GND0
Xix1491 nand02 $PINS Y=nx1490 A0=nx22897 A1=nx23073
Xix22898 nor02_2x $PINS Y=nx22897 A0=nx1050 A1=nx1024
Xix1039 xnor2 $PINS Y=nx1038 A0=nx1004 A1=nx23033
Xix1005 oai22 $PINS Y=nx1004 A0=nx22907 A1=nx23012 B0=nx23011 B1=nx37196
Xcamera_module_algo_module_Address_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_address_value_5 QB=nx23011 D=nx1193 CLK=clk
Xix1194 mux21_ni $PINS Y=nx1193 A0=nx552
+ A1=camera_module_algo_module_address_value_5 S0=nx37198
Xix553 oai32 $PINS Y=nx552 A0=nx22912 A1=nx34120
+ A2=camera_module_algo_module_prev_cont_enable B0=nx35672 B1=nx35786
Xix22913 xnor2 $PINS Y=nx22912 A0=nx22915 A1=nx22907
Xix22916 aoi22 $PINS Y=nx22915 A0=camera_module_algo_module_address_value_4
+ A1=nx34140 B0=nx518 B1=nx905
Xcamera_module_algo_module_Address_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_address_value_4 QB=#dummy[18] D=nx1183 CLK=clk
Xix1184 mux21_ni $PINS Y=nx1183 A0=nx528
+ A1=camera_module_algo_module_address_value_4 S0=nx37198
Xix521 xnor2 $PINS Y=nx520 A0=nx518 A1=nx23006
Xix519 oai22 $PINS Y=nx518 A0=nx22923 A1=nx22997 B0=nx23005 B1=nx37196
Xix22924 aoi22 $PINS Y=nx22923 A0=camera_module_algo_module_address_value_2
+ A1=nx34140 B0=nx460 B1=nx903
Xcamera_module_algo_module_Address_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_address_value_2 QB=#dummy[19] D=nx1163 CLK=clk
Xix1164 mux21_ni $PINS Y=nx1163 A0=nx470
+ A1=camera_module_algo_module_address_value_2 S0=nx37198
Xix463 xnor2 $PINS Y=nx462 A0=nx460 A1=nx22951
Xix461 oai22 $PINS Y=nx460 A0=nx22577 A1=nx22931 B0=nx22935 B1=nx37196
Xix437 xnor2 $PINS Y=nx436 A0=zero A1=nx37094
Xcamera_module_algo_module_Address_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_address_value_1 QB=nx22935 D=nx1153 CLK=clk
Xix1094 oai21 $PINS Y=nx1093 A0=nx22943 A1=nx34036 B0=nx22945
Xcamera_module_algo_module_modCU_reg_current_state_8 dff $PINS Q=#dummy[20]
+ QB=nx22943 D=nx1093 CLK=clk
Xix22946 nand03 $PINS Y=nx22945 A0=nx35692
+ A1=camera_module_algo_module_modCU_current_state_7 A2=nx34036
Xcamera_module_algo_module_modCU_reg_current_state_7 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_7 QB=#dummy[21] D=nx1083
+ CLK=clk
Xcamera_module_algo_module_modCU_reg_current_state_16 dff $PINS
+ Q=camera_module_algo_module_prev_cont_enable QB=#dummy[22] D=nx22513 CLK=clk
Xix22514 ao32 $PINS Y=nx22513 A0=motor_move A1=motor_done A2=nx35692
+ B0=camera_module_algo_module_prev_cont_enable B1=nx35696
Xcamera_module_algo_module_modCU_reg_current_state_15 dff $PINS Q=motor_move
+ QB=#dummy[23] D=nx22503 CLK=clk
Xix27085 nor02_2x $PINS Y=nx27084 A0=rst A1=nx22961
Xix22962 aoi22 $PINS Y=nx22961 A0=nx22963
+ A1=camera_module_algo_module_modCU_current_state_14
+ B0=camera_module_algo_module_modCU_current_state_13 B1=nx22627
Xix22494 mux21_ni $PINS Y=nx22493 A0=nx27068
+ A1=camera_module_algo_module_failure_count_value_0 S0=nx22968
Xcamera_module_algo_module_fail_count_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_failure_count_value_0 QB=nx22963 D=nx22493 CLK=clk
Xix22969 nor03_2x $PINS Y=nx22968
+ A0=camera_module_algo_module_modCU_current_state_14 A1=motor_move A2=nx34118
Xix1124 oai21 $PINS Y=nx1123 A0=nx22979 A1=nx34036 B0=nx22981
Xcamera_module_algo_module_modCU_reg_current_state_11 dff $PINS Q=#dummy[24]
+ QB=nx22979 D=nx1123 CLK=clk
Xix1114 oai21 $PINS Y=nx1113 A0=nx22987 A1=nx34038 B0=nx22989
Xcamera_module_algo_module_modCU_reg_current_state_10 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_10 QB=nx22987 D=nx1113 CLK=clk
Xix1104 oai22 $PINS Y=nx1103 A0=nx22993 A1=nx34038 B0=rst B1=nx22943
Xcamera_module_algo_module_modCU_reg_current_state_9 dff $PINS Q=#dummy[25]
+ QB=nx22993 D=nx1103 CLK=clk
Xcamera_module_algo_module_Address_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_address_value_3 QB=nx23005 D=nx1173 CLK=clk
Xix1174 mux21_ni $PINS Y=nx1173 A0=nx496
+ A1=camera_module_algo_module_address_value_3 S0=nx37198
Xix497 oai32 $PINS Y=nx496 A0=nx23003 A1=nx34118
+ A2=camera_module_algo_module_prev_cont_enable B0=nx35672 B1=nx35786
Xix23004 xnor2 $PINS Y=nx23003 A0=nx22923 A1=nx22997
Xix23013 aoi22 $PINS Y=nx23012 A0=camera_module_algo_module_address_value_4
+ A1=nx426 B0=nx932 B1=nx934
Xix427 xnor2 $PINS Y=nx426 A0=one A1=nx37094
Xix933 oai22 $PINS Y=nx932 A0=nx22997 A1=nx23016 B0=nx23005 B1=nx37196
Xix23017 aoi22 $PINS Y=nx23016 A0=camera_module_algo_module_address_value_2
+ A1=nx34142 B0=nx903 B1=nx860
Xix861 oai22 $PINS Y=nx860 A0=nx22935 A1=nx37196 B0=nx22931 B1=nx23019
Xix23020 mux21_ni $PINS Y=nx23019 A0=nx37094 A1=nx23021 S0=zero
Xix1144 mux21_ni $PINS Y=nx1143 A0=nx418
+ A1=camera_module_algo_module_address_value_0 S0=nx37198
Xix419 oai32 $PINS Y=nx418 A0=nx23026 A1=nx34120
+ A2=camera_module_algo_module_prev_cont_enable B0=nx35672 B1=nx35786
Xcamera_module_algo_module_Address_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_address_value_0 QB=nx23021 D=nx1143 CLK=clk
Xcamera_module_algo_module_Address_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_address_value_6 QB=#dummy[26] D=nx1203 CLK=clk
Xix1204 mux21_ni $PINS Y=nx1203 A0=nx576
+ A1=camera_module_algo_module_address_value_6 S0=nx37198
Xix569 xnor2 $PINS Y=nx568 A0=nx566 A1=nx23033
Xix567 oai22 $PINS Y=nx566 A0=nx22915 A1=nx22907 B0=nx23011 B1=nx37196
Xcamera_module_algo_module_modCU_reg_current_state_4 dff $PINS Q=#dummy[27]
+ QB=nx22597 D=nx1053 CLK=clk
Xix1017 oai32 $PINS Y=nx1016 A0=camera_module_algo_module_modCU_current_state_6
+ A1=camera_module_algo_module_modCU_current_state_10 A2=nx23051 B0=nx35804
+ B1=nx23069
Xix23054 xnor2 $PINS Y=nx23053 A0=nx23055 A1=nx23059
Xix23056 aoi22 $PINS Y=nx23055 A0=camera_module_algo_module_address_value_6
+ A1=nx34142 B0=nx566 B1=nx908
Xcamera_module_algo_module_Address_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_address_value_7 QB=nx23067 D=nx1213 CLK=clk
Xix1214 mux21_ni $PINS Y=nx1213 A0=nx602
+ A1=camera_module_algo_module_address_value_7 S0=nx22973
Xix603 oai32 $PINS Y=nx602 A0=nx23053 A1=nx34120
+ A2=camera_module_algo_module_prev_cont_enable B0=nx35672 B1=nx35786
Xix23070 xnor2 $PINS Y=nx23069 A0=nx23071 A1=nx23059
Xix23072 aoi22 $PINS Y=nx23071 A0=camera_module_algo_module_address_value_6
+ A1=nx34142 B0=nx908 B1=nx1004
Xix23074 nor02_2x $PINS Y=nx23073 A0=nx980 A1=nx954
Xix969 xnor2 $PINS Y=nx968 A0=nx932 A1=nx23079
Xix23080 xnor2 $PINS Y=nx23079 A0=camera_module_algo_module_address_value_4
+ A1=nx426
Xix947 oai32 $PINS Y=nx946 A0=camera_module_algo_module_modCU_current_state_6
+ A1=camera_module_algo_module_modCU_current_state_10 A2=nx23084 B0=nx35804
+ B1=nx23087
Xix23088 xnor2 $PINS Y=nx23087 A0=nx23012 A1=nx22907
Xix5651 nand02 $PINS Y=nx5650 A0=nx23091 A1=nx23105
Xix23092 nor02_2x $PINS Y=nx23091 A0=nx906 A1=nx880
Xix895 xnor2 $PINS Y=nx894 A0=nx860 A1=nx22951
Xix873 oai32 $PINS Y=nx872 A0=camera_module_algo_module_modCU_current_state_6
+ A1=camera_module_algo_module_modCU_current_state_10 A2=nx23100 B0=nx35804
+ B1=nx23102
Xix23103 xnor2 $PINS Y=nx23102 A0=nx23016 A1=nx22997
Xix23106 nor02_2x $PINS Y=nx23105 A0=nx836 A1=nx810
Xix829 oai32 $PINS Y=nx828 A0=camera_module_algo_module_modCU_current_state_6
+ A1=camera_module_algo_module_modCU_current_state_10 A2=nx23111 B0=nx35804
+ B1=nx23113
Xix803 oai32 $PINS Y=nx802 A0=camera_module_algo_module_modCU_current_state_6
+ A1=camera_module_algo_module_modCU_current_state_10 A2=nx23117 B0=nx23119
+ B1=nx35806
Xix23120 xnor2 $PINS Y=nx23119 A0=nx23019 A1=nx22931
Xcamera_module_cache_reg_ram_16__6 dffr $PINS Q=camera_module_cache_ram_16__6
+ QB=#dummy[28] D=nx19223 CLK=clk R=rst
Xix19224 mux21_ni $PINS Y=nx19223 A0=camera_module_cache_ram_16__6 A1=nx35520
+ S0=nx35130
Xix1473 nand02 $PINS Y=nx1472 A0=nx23130 A1=nx22897
Xix23139 aoi22 $PINS Y=nx23138 A0=camera_module_cache_ram_32__6 A1=nx37034
+ B0=camera_module_cache_ram_48__6 B1=nx37036
Xcamera_module_cache_reg_ram_32__6 dffr $PINS Q=camera_module_cache_ram_32__6
+ QB=#dummy[29] D=nx19213 CLK=clk R=rst
Xix19214 mux21_ni $PINS Y=nx19213 A0=camera_module_cache_ram_32__6 A1=nx35520
+ S0=nx35126
Xix1453 nand02 $PINS Y=nx1452 A0=nx23145 A1=nx22897
Xcamera_module_cache_reg_ram_48__6 dffr $PINS Q=camera_module_cache_ram_48__6
+ QB=#dummy[30] D=nx19203 CLK=clk R=rst
Xix19204 mux21_ni $PINS Y=nx19203 A0=camera_module_cache_ram_48__6 A1=nx35520
+ S0=nx35122
Xix1435 nand02 $PINS Y=nx1434 A0=nx23157 A1=nx22897
Xix987 nand02 $PINS Y=nx986 A0=nx980 A1=nx954
Xix23166 aoi22 $PINS Y=nx23165 A0=camera_module_cache_ram_64__6 A1=nx37038
+ B0=camera_module_cache_ram_80__6 B1=nx37040
Xcamera_module_cache_reg_ram_64__6 dffr $PINS Q=camera_module_cache_ram_64__6
+ QB=#dummy[31] D=nx19193 CLK=clk R=rst
Xix19194 mux21_ni $PINS Y=nx19193 A0=camera_module_cache_ram_64__6 A1=nx35520
+ S0=nx35118
Xix1411 nand02 $PINS Y=nx1410 A0=nx23172 A1=nx23073
Xcamera_module_cache_reg_ram_80__6 dffr $PINS Q=camera_module_cache_ram_80__6
+ QB=#dummy[32] D=nx19183 CLK=clk R=rst
Xix19184 mux21_ni $PINS Y=nx19183 A0=camera_module_cache_ram_80__6 A1=nx35520
+ S0=nx35114
Xix1393 nand02 $PINS Y=nx1392 A0=nx23172 A1=nx23130
Xix23190 aoi22 $PINS Y=nx23189 A0=camera_module_cache_ram_112__6 A1=nx37042
+ B0=camera_module_cache_ram_96__6 B1=nx37044
Xcamera_module_cache_reg_ram_112__6 dffr $PINS Q=camera_module_cache_ram_112__6
+ QB=#dummy[33] D=nx19163 CLK=clk R=rst
Xix19164 mux21_ni $PINS Y=nx19163 A0=camera_module_cache_ram_112__6 A1=nx35520
+ S0=nx35106
Xix1355 nand02 $PINS Y=nx1354 A0=nx23172 A1=nx23157
Xcamera_module_cache_reg_ram_96__6 dffr $PINS Q=camera_module_cache_ram_96__6
+ QB=#dummy[34] D=nx19173 CLK=clk R=rst
Xix19174 mux21_ni $PINS Y=nx19173 A0=camera_module_cache_ram_96__6 A1=nx35522
+ S0=nx35110
Xix1373 nand02 $PINS Y=nx1372 A0=nx23172 A1=nx23145
Xix22501 nand04 $PINS Y=nx22500 A0=nx23211 A1=nx23236 A2=nx23256 A3=nx23282
Xix23212 aoi22 $PINS Y=nx23211 A0=camera_module_cache_ram_128__6 A1=nx37046
+ B0=camera_module_cache_ram_144__6 B1=nx37048
Xcamera_module_cache_reg_ram_128__6 dffr $PINS Q=camera_module_cache_ram_128__6
+ QB=#dummy[35] D=nx19153 CLK=clk R=rst
Xix19154 mux21_ni $PINS Y=nx19153 A0=camera_module_cache_ram_128__6 A1=nx35522
+ S0=nx35102
Xix1327 nand02 $PINS Y=nx1326 A0=nx23218 A1=nx23073
Xcamera_module_cache_reg_ram_144__6 dffr $PINS Q=camera_module_cache_ram_144__6
+ QB=#dummy[36] D=nx19143 CLK=clk R=rst
Xix19144 mux21_ni $PINS Y=nx19143 A0=camera_module_cache_ram_144__6 A1=nx35522
+ S0=nx35098
Xix1309 nand02 $PINS Y=nx1308 A0=nx23218 A1=nx23130
Xix23237 aoi22 $PINS Y=nx23236 A0=camera_module_cache_ram_176__6 A1=nx37050
+ B0=camera_module_cache_ram_160__6 B1=nx37052
Xcamera_module_cache_reg_ram_176__6 dffr $PINS Q=camera_module_cache_ram_176__6
+ QB=#dummy[37] D=nx19123 CLK=clk R=rst
Xix19124 mux21_ni $PINS Y=nx19123 A0=camera_module_cache_ram_176__6 A1=nx35522
+ S0=nx35090
Xix1271 nand02 $PINS Y=nx1270 A0=nx23218 A1=nx23157
Xcamera_module_cache_reg_ram_160__6 dffr $PINS Q=camera_module_cache_ram_160__6
+ QB=#dummy[38] D=nx19133 CLK=clk R=rst
Xix19134 mux21_ni $PINS Y=nx19133 A0=camera_module_cache_ram_160__6 A1=nx35522
+ S0=nx35094
Xix1289 nand02 $PINS Y=nx1288 A0=nx23218 A1=nx23145
Xix23257 aoi22 $PINS Y=nx23256 A0=camera_module_cache_ram_192__6 A1=nx36288
+ B0=camera_module_cache_ram_208__6 B1=nx36328
Xcamera_module_cache_reg_ram_192__6 dffr $PINS Q=camera_module_cache_ram_192__6
+ QB=#dummy[39] D=nx19113 CLK=clk R=rst
Xix19114 mux21_ni $PINS Y=nx19113 A0=camera_module_cache_ram_192__6 A1=nx35522
+ S0=nx35086
Xix1057 nand02 $PINS Y=nx1056 A0=nx1050 A1=nx1024
Xcamera_module_cache_reg_ram_208__6 dffr $PINS Q=camera_module_cache_ram_208__6
+ QB=#dummy[40] D=nx19103 CLK=clk R=rst
Xix19104 mux21_ni $PINS Y=nx19103 A0=camera_module_cache_ram_208__6 A1=nx35522
+ S0=nx35082
Xix23283 aoi22 $PINS Y=nx23282 A0=camera_module_cache_ram_224__6 A1=nx36368
+ B0=camera_module_cache_ram_240__6 B1=nx36408
Xcamera_module_cache_reg_ram_224__6 dffr $PINS Q=camera_module_cache_ram_224__6
+ QB=#dummy[41] D=nx19093 CLK=clk R=rst
Xix19094 mux21_ni $PINS Y=nx19093 A0=camera_module_cache_ram_224__6 A1=nx35524
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__6 dffr $PINS Q=camera_module_cache_ram_240__6
+ QB=#dummy[42] D=nx19083 CLK=clk R=rst
Xix19084 mux21_ni $PINS Y=nx19083 A0=camera_module_cache_ram_240__6 A1=nx35524
+ S0=nx35074
Xix23299 nor02_2x $PINS Y=nx23298 A0=nx1056 A1=nx986
Xix23303 oai21 $PINS Y=nx23302 A0=nx22416 A1=nx22338 B0=nx36452
Xix22417 nand04 $PINS Y=nx22416 A0=nx23305 A1=nx23324 A2=nx23337 A3=nx23349
Xix23306 aoi22 $PINS Y=nx23305 A0=camera_module_cache_ram_1__6 A1=nx37030
+ B0=camera_module_cache_ram_17__6 B1=nx37032
Xcamera_module_cache_reg_ram_1__6 dffr $PINS Q=camera_module_cache_ram_1__6
+ QB=#dummy[43] D=nx19073 CLK=clk R=rst
Xix19074 mux21_ni $PINS Y=nx19073 A0=camera_module_cache_ram_1__6 A1=nx35524
+ S0=nx35064
Xix5359 nand02 $PINS Y=nx5358 A0=nx23314 A1=nx23091
Xcamera_module_cache_reg_ram_17__6 dffr $PINS Q=camera_module_cache_ram_17__6
+ QB=#dummy[44] D=nx19063 CLK=clk R=rst
Xix19064 mux21_ni $PINS Y=nx19063 A0=camera_module_cache_ram_17__6 A1=nx35524
+ S0=nx35060
Xix23325 aoi22 $PINS Y=nx23324 A0=camera_module_cache_ram_33__6 A1=nx37034
+ B0=camera_module_cache_ram_49__6 B1=nx37036
Xcamera_module_cache_reg_ram_33__6 dffr $PINS Q=camera_module_cache_ram_33__6
+ QB=#dummy[45] D=nx19053 CLK=clk R=rst
Xix19054 mux21_ni $PINS Y=nx19053 A0=camera_module_cache_ram_33__6 A1=nx35524
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__6 dffr $PINS Q=camera_module_cache_ram_49__6
+ QB=#dummy[46] D=nx19043 CLK=clk R=rst
Xix19044 mux21_ni $PINS Y=nx19043 A0=camera_module_cache_ram_49__6 A1=nx35524
+ S0=nx35052
Xix23338 aoi22 $PINS Y=nx23337 A0=camera_module_cache_ram_65__6 A1=nx37038
+ B0=camera_module_cache_ram_81__6 B1=nx37040
Xcamera_module_cache_reg_ram_65__6 dffr $PINS Q=camera_module_cache_ram_65__6
+ QB=#dummy[47] D=nx19033 CLK=clk R=rst
Xix19034 mux21_ni $PINS Y=nx19033 A0=camera_module_cache_ram_65__6 A1=nx35524
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__6 dffr $PINS Q=camera_module_cache_ram_81__6
+ QB=#dummy[48] D=nx19023 CLK=clk R=rst
Xix19024 mux21_ni $PINS Y=nx19023 A0=camera_module_cache_ram_81__6 A1=nx35526
+ S0=nx35044
Xix23350 aoi22 $PINS Y=nx23349 A0=camera_module_cache_ram_113__6 A1=nx37042
+ B0=camera_module_cache_ram_97__6 B1=nx37044
Xcamera_module_cache_reg_ram_113__6 dffr $PINS Q=camera_module_cache_ram_113__6
+ QB=#dummy[49] D=nx19003 CLK=clk R=rst
Xix19004 mux21_ni $PINS Y=nx19003 A0=camera_module_cache_ram_113__6 A1=nx35526
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__6 dffr $PINS Q=camera_module_cache_ram_97__6
+ QB=#dummy[50] D=nx19013 CLK=clk R=rst
Xix19014 mux21_ni $PINS Y=nx19013 A0=camera_module_cache_ram_97__6 A1=nx35526
+ S0=nx35040
Xix22339 nand04 $PINS Y=nx22338 A0=nx23361 A1=nx23372 A2=nx23385 A3=nx23400
Xix23362 aoi22 $PINS Y=nx23361 A0=camera_module_cache_ram_129__6 A1=nx37046
+ B0=camera_module_cache_ram_145__6 B1=nx37048
Xcamera_module_cache_reg_ram_129__6 dffr $PINS Q=camera_module_cache_ram_129__6
+ QB=#dummy[51] D=nx18993 CLK=clk R=rst
Xix18994 mux21_ni $PINS Y=nx18993 A0=camera_module_cache_ram_129__6 A1=nx35526
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__6 dffr $PINS Q=camera_module_cache_ram_145__6
+ QB=#dummy[52] D=nx18983 CLK=clk R=rst
Xix18984 mux21_ni $PINS Y=nx18983 A0=camera_module_cache_ram_145__6 A1=nx35526
+ S0=nx35028
Xix23373 aoi22 $PINS Y=nx23372 A0=camera_module_cache_ram_177__6 A1=nx37050
+ B0=camera_module_cache_ram_161__6 B1=nx37052
Xcamera_module_cache_reg_ram_177__6 dffr $PINS Q=camera_module_cache_ram_177__6
+ QB=#dummy[53] D=nx18963 CLK=clk R=rst
Xix18964 mux21_ni $PINS Y=nx18963 A0=camera_module_cache_ram_177__6 A1=nx35526
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__6 dffr $PINS Q=camera_module_cache_ram_161__6
+ QB=#dummy[54] D=nx18973 CLK=clk R=rst
Xix18974 mux21_ni $PINS Y=nx18973 A0=camera_module_cache_ram_161__6 A1=nx35526
+ S0=nx35024
Xix23386 aoi22 $PINS Y=nx23385 A0=camera_module_cache_ram_193__6 A1=nx36288
+ B0=camera_module_cache_ram_209__6 B1=nx36328
Xcamera_module_cache_reg_ram_193__6 dffr $PINS Q=camera_module_cache_ram_193__6
+ QB=#dummy[55] D=nx18953 CLK=clk R=rst
Xix18954 mux21_ni $PINS Y=nx18953 A0=camera_module_cache_ram_193__6 A1=nx35528
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__6 dffr $PINS Q=camera_module_cache_ram_209__6
+ QB=#dummy[56] D=nx18943 CLK=clk R=rst
Xix18944 mux21_ni $PINS Y=nx18943 A0=camera_module_cache_ram_209__6 A1=nx35528
+ S0=nx35012
Xix23401 aoi22 $PINS Y=nx23400 A0=camera_module_cache_ram_225__6 A1=nx36368
+ B0=camera_module_cache_ram_241__6 B1=nx36408
Xcamera_module_cache_reg_ram_225__6 dffr $PINS Q=camera_module_cache_ram_225__6
+ QB=#dummy[57] D=nx18933 CLK=clk R=rst
Xix18934 mux21_ni $PINS Y=nx18933 A0=camera_module_cache_ram_225__6 A1=nx35528
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__6 dffr $PINS Q=camera_module_cache_ram_241__6
+ QB=#dummy[58] D=nx18923 CLK=clk R=rst
Xix18924 mux21_ni $PINS Y=nx18923 A0=camera_module_cache_ram_241__6 A1=nx35528
+ S0=nx35004
Xix23414 oai21 $PINS Y=nx23413 A0=nx22252 A1=nx22174 B0=nx36456
Xix22253 nand04 $PINS Y=nx22252 A0=nx23417 A1=nx23433 A2=nx23446 A3=nx23458
Xix23418 aoi22 $PINS Y=nx23417 A0=camera_module_cache_ram_2__6 A1=nx37030
+ B0=camera_module_cache_ram_18__6 B1=nx37032
Xcamera_module_cache_reg_ram_2__6 dffr $PINS Q=camera_module_cache_ram_2__6
+ QB=#dummy[59] D=nx18913 CLK=clk R=rst
Xix18914 mux21_ni $PINS Y=nx18913 A0=camera_module_cache_ram_2__6 A1=nx35528
+ S0=nx34994
Xix5065 nand02 $PINS Y=nx5064 A0=nx23423 A1=nx23091
Xcamera_module_cache_reg_ram_18__6 dffr $PINS Q=camera_module_cache_ram_18__6
+ QB=#dummy[60] D=nx18903 CLK=clk R=rst
Xix18904 mux21_ni $PINS Y=nx18903 A0=camera_module_cache_ram_18__6 A1=nx35528
+ S0=nx34990
Xix23434 aoi22 $PINS Y=nx23433 A0=camera_module_cache_ram_34__6 A1=nx37034
+ B0=camera_module_cache_ram_50__6 B1=nx37036
Xcamera_module_cache_reg_ram_34__6 dffr $PINS Q=camera_module_cache_ram_34__6
+ QB=#dummy[61] D=nx18893 CLK=clk R=rst
Xix18894 mux21_ni $PINS Y=nx18893 A0=camera_module_cache_ram_34__6 A1=nx35528
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__6 dffr $PINS Q=camera_module_cache_ram_50__6
+ QB=#dummy[62] D=nx18883 CLK=clk R=rst
Xix18884 mux21_ni $PINS Y=nx18883 A0=camera_module_cache_ram_50__6 A1=nx35530
+ S0=nx34982
Xix23447 aoi22 $PINS Y=nx23446 A0=camera_module_cache_ram_66__6 A1=nx37038
+ B0=camera_module_cache_ram_82__6 B1=nx37040
Xcamera_module_cache_reg_ram_66__6 dffr $PINS Q=camera_module_cache_ram_66__6
+ QB=#dummy[63] D=nx18873 CLK=clk R=rst
Xix18874 mux21_ni $PINS Y=nx18873 A0=camera_module_cache_ram_66__6 A1=nx35530
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__6 dffr $PINS Q=camera_module_cache_ram_82__6
+ QB=#dummy[64] D=nx18863 CLK=clk R=rst
Xix18864 mux21_ni $PINS Y=nx18863 A0=camera_module_cache_ram_82__6 A1=nx35530
+ S0=nx34974
Xix23459 aoi22 $PINS Y=nx23458 A0=camera_module_cache_ram_114__6 A1=nx37042
+ B0=camera_module_cache_ram_98__6 B1=nx37044
Xcamera_module_cache_reg_ram_114__6 dffr $PINS Q=camera_module_cache_ram_114__6
+ QB=#dummy[65] D=nx18843 CLK=clk R=rst
Xix18844 mux21_ni $PINS Y=nx18843 A0=camera_module_cache_ram_114__6 A1=nx35530
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__6 dffr $PINS Q=camera_module_cache_ram_98__6
+ QB=#dummy[66] D=nx18853 CLK=clk R=rst
Xix18854 mux21_ni $PINS Y=nx18853 A0=camera_module_cache_ram_98__6 A1=nx35530
+ S0=nx34970
Xix22175 nand04 $PINS Y=nx22174 A0=nx23469 A1=nx23482 A2=nx23495 A3=nx23506
Xix23470 aoi22 $PINS Y=nx23469 A0=camera_module_cache_ram_130__6 A1=nx37046
+ B0=camera_module_cache_ram_146__6 B1=nx37048
Xcamera_module_cache_reg_ram_130__6 dffr $PINS Q=camera_module_cache_ram_130__6
+ QB=#dummy[67] D=nx18833 CLK=clk R=rst
Xix18834 mux21_ni $PINS Y=nx18833 A0=camera_module_cache_ram_130__6 A1=nx35530
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__6 dffr $PINS Q=camera_module_cache_ram_146__6
+ QB=#dummy[68] D=nx18823 CLK=clk R=rst
Xix18824 mux21_ni $PINS Y=nx18823 A0=camera_module_cache_ram_146__6 A1=nx35530
+ S0=nx34958
Xix23483 aoi22 $PINS Y=nx23482 A0=camera_module_cache_ram_178__6 A1=nx37050
+ B0=camera_module_cache_ram_162__6 B1=nx37052
Xcamera_module_cache_reg_ram_178__6 dffr $PINS Q=camera_module_cache_ram_178__6
+ QB=#dummy[69] D=nx18803 CLK=clk R=rst
Xix18804 mux21_ni $PINS Y=nx18803 A0=camera_module_cache_ram_178__6 A1=nx35532
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__6 dffr $PINS Q=camera_module_cache_ram_162__6
+ QB=#dummy[70] D=nx18813 CLK=clk R=rst
Xix18814 mux21_ni $PINS Y=nx18813 A0=camera_module_cache_ram_162__6 A1=nx35532
+ S0=nx34954
Xix23496 aoi22 $PINS Y=nx23495 A0=camera_module_cache_ram_194__6 A1=nx36288
+ B0=camera_module_cache_ram_210__6 B1=nx36328
Xcamera_module_cache_reg_ram_194__6 dffr $PINS Q=camera_module_cache_ram_194__6
+ QB=#dummy[71] D=nx18793 CLK=clk R=rst
Xix18794 mux21_ni $PINS Y=nx18793 A0=camera_module_cache_ram_194__6 A1=nx35532
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__6 dffr $PINS Q=camera_module_cache_ram_210__6
+ QB=#dummy[72] D=nx18783 CLK=clk R=rst
Xix18784 mux21_ni $PINS Y=nx18783 A0=camera_module_cache_ram_210__6 A1=nx35532
+ S0=nx34942
Xix23507 aoi22 $PINS Y=nx23506 A0=camera_module_cache_ram_226__6 A1=nx36368
+ B0=camera_module_cache_ram_242__6 B1=nx36408
Xcamera_module_cache_reg_ram_226__6 dffr $PINS Q=camera_module_cache_ram_226__6
+ QB=#dummy[73] D=nx18773 CLK=clk R=rst
Xix18774 mux21_ni $PINS Y=nx18773 A0=camera_module_cache_ram_226__6 A1=nx35532
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__6 dffr $PINS Q=camera_module_cache_ram_242__6
+ QB=#dummy[74] D=nx18763 CLK=clk R=rst
Xix18764 mux21_ni $PINS Y=nx18763 A0=camera_module_cache_ram_242__6 A1=nx35532
+ S0=nx34934
Xix23521 oai21 $PINS Y=nx23520 A0=nx22090 A1=nx22012 B0=nx36460
Xix22091 nand04 $PINS Y=nx22090 A0=nx23523 A1=nx23537 A2=nx23549 A3=nx23562
Xix23524 aoi22 $PINS Y=nx23523 A0=camera_module_cache_ram_3__6 A1=nx37030
+ B0=camera_module_cache_ram_19__6 B1=nx37032
Xcamera_module_cache_reg_ram_3__6 dffr $PINS Q=camera_module_cache_ram_3__6
+ QB=#dummy[75] D=nx18753 CLK=clk R=rst
Xix18754 mux21_ni $PINS Y=nx18753 A0=camera_module_cache_ram_3__6 A1=nx35532
+ S0=nx34924
Xix4773 nand02 $PINS Y=nx4772 A0=nx23529 A1=nx23091
Xcamera_module_cache_reg_ram_19__6 dffr $PINS Q=camera_module_cache_ram_19__6
+ QB=#dummy[76] D=nx18743 CLK=clk R=rst
Xix18744 mux21_ni $PINS Y=nx18743 A0=camera_module_cache_ram_19__6 A1=nx35534
+ S0=nx34920
Xix23538 aoi22 $PINS Y=nx23537 A0=camera_module_cache_ram_35__6 A1=nx37034
+ B0=camera_module_cache_ram_51__6 B1=nx37036
Xcamera_module_cache_reg_ram_35__6 dffr $PINS Q=camera_module_cache_ram_35__6
+ QB=#dummy[77] D=nx18733 CLK=clk R=rst
Xix18734 mux21_ni $PINS Y=nx18733 A0=camera_module_cache_ram_35__6 A1=nx35534
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__6 dffr $PINS Q=camera_module_cache_ram_51__6
+ QB=#dummy[78] D=nx18723 CLK=clk R=rst
Xix18724 mux21_ni $PINS Y=nx18723 A0=camera_module_cache_ram_51__6 A1=nx35534
+ S0=nx34912
Xix23550 aoi22 $PINS Y=nx23549 A0=camera_module_cache_ram_67__6 A1=nx37038
+ B0=camera_module_cache_ram_83__6 B1=nx37040
Xcamera_module_cache_reg_ram_67__6 dffr $PINS Q=camera_module_cache_ram_67__6
+ QB=#dummy[79] D=nx18713 CLK=clk R=rst
Xix18714 mux21_ni $PINS Y=nx18713 A0=camera_module_cache_ram_67__6 A1=nx35534
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__6 dffr $PINS Q=camera_module_cache_ram_83__6
+ QB=#dummy[80] D=nx18703 CLK=clk R=rst
Xix18704 mux21_ni $PINS Y=nx18703 A0=camera_module_cache_ram_83__6 A1=nx35534
+ S0=nx34904
Xix23563 aoi22 $PINS Y=nx23562 A0=camera_module_cache_ram_115__6 A1=nx37042
+ B0=camera_module_cache_ram_99__6 B1=nx37044
Xcamera_module_cache_reg_ram_115__6 dffr $PINS Q=camera_module_cache_ram_115__6
+ QB=#dummy[81] D=nx18683 CLK=clk R=rst
Xix18684 mux21_ni $PINS Y=nx18683 A0=camera_module_cache_ram_115__6 A1=nx35534
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__6 dffr $PINS Q=camera_module_cache_ram_99__6
+ QB=#dummy[82] D=nx18693 CLK=clk R=rst
Xix18694 mux21_ni $PINS Y=nx18693 A0=camera_module_cache_ram_99__6 A1=nx35534
+ S0=nx34900
Xix22013 nand04 $PINS Y=nx22012 A0=nx23574 A1=nx23587 A2=nx23599 A3=nx23610
Xix23575 aoi22 $PINS Y=nx23574 A0=camera_module_cache_ram_131__6 A1=nx37046
+ B0=camera_module_cache_ram_147__6 B1=nx37048
Xcamera_module_cache_reg_ram_131__6 dffr $PINS Q=camera_module_cache_ram_131__6
+ QB=#dummy[83] D=nx18673 CLK=clk R=rst
Xix18674 mux21_ni $PINS Y=nx18673 A0=camera_module_cache_ram_131__6 A1=nx35536
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__6 dffr $PINS Q=camera_module_cache_ram_147__6
+ QB=#dummy[84] D=nx18663 CLK=clk R=rst
Xix18664 mux21_ni $PINS Y=nx18663 A0=camera_module_cache_ram_147__6 A1=nx35536
+ S0=nx34888
Xix23588 aoi22 $PINS Y=nx23587 A0=camera_module_cache_ram_179__6 A1=nx37050
+ B0=camera_module_cache_ram_163__6 B1=nx37052
Xcamera_module_cache_reg_ram_179__6 dffr $PINS Q=camera_module_cache_ram_179__6
+ QB=#dummy[85] D=nx18643 CLK=clk R=rst
Xix18644 mux21_ni $PINS Y=nx18643 A0=camera_module_cache_ram_179__6 A1=nx35536
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__6 dffr $PINS Q=camera_module_cache_ram_163__6
+ QB=#dummy[86] D=nx18653 CLK=clk R=rst
Xix18654 mux21_ni $PINS Y=nx18653 A0=camera_module_cache_ram_163__6 A1=nx35536
+ S0=nx34884
Xix23600 aoi22 $PINS Y=nx23599 A0=camera_module_cache_ram_195__6 A1=nx36288
+ B0=camera_module_cache_ram_211__6 B1=nx36328
Xcamera_module_cache_reg_ram_195__6 dffr $PINS Q=camera_module_cache_ram_195__6
+ QB=#dummy[87] D=nx18633 CLK=clk R=rst
Xix18634 mux21_ni $PINS Y=nx18633 A0=camera_module_cache_ram_195__6 A1=nx35536
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__6 dffr $PINS Q=camera_module_cache_ram_211__6
+ QB=#dummy[88] D=nx18623 CLK=clk R=rst
Xix18624 mux21_ni $PINS Y=nx18623 A0=camera_module_cache_ram_211__6 A1=nx35536
+ S0=nx34872
Xix23611 aoi22 $PINS Y=nx23610 A0=camera_module_cache_ram_227__6 A1=nx36368
+ B0=camera_module_cache_ram_243__6 B1=nx36408
Xcamera_module_cache_reg_ram_227__6 dffr $PINS Q=camera_module_cache_ram_227__6
+ QB=#dummy[89] D=nx18613 CLK=clk R=rst
Xix18614 mux21_ni $PINS Y=nx18613 A0=camera_module_cache_ram_227__6 A1=nx35536
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__6 dffr $PINS Q=camera_module_cache_ram_243__6
+ QB=#dummy[90] D=nx18603 CLK=clk R=rst
Xix18604 mux21_ni $PINS Y=nx18603 A0=camera_module_cache_ram_243__6 A1=nx35538
+ S0=nx34864
Xix843 nand02 $PINS Y=nx842 A0=nx836 A1=nx810
Xix21935 nand04 $PINS Y=nx21934 A0=nx23627 A1=nx23733 A2=nx23835 A3=nx23938
Xix23628 oai21 $PINS Y=nx23627 A0=nx21924 A1=nx21846 B0=nx36464
Xix21925 nand04 $PINS Y=nx21924 A0=nx23630 A1=nx23648 A2=nx23660 A3=nx23670
Xix23631 aoi22 $PINS Y=nx23630 A0=camera_module_cache_ram_4__6 A1=nx37030
+ B0=camera_module_cache_ram_20__6 B1=nx37032
Xcamera_module_cache_reg_ram_4__6 dffr $PINS Q=camera_module_cache_ram_4__6
+ QB=#dummy[91] D=nx18593 CLK=clk R=rst
Xix18594 mux21_ni $PINS Y=nx18593 A0=camera_module_cache_ram_4__6 A1=nx35538
+ S0=nx34854
Xix4475 nand02 $PINS Y=nx4474 A0=nx23639 A1=nx23105
Xcamera_module_cache_reg_ram_20__6 dffr $PINS Q=camera_module_cache_ram_20__6
+ QB=#dummy[92] D=nx18583 CLK=clk R=rst
Xix18584 mux21_ni $PINS Y=nx18583 A0=camera_module_cache_ram_20__6 A1=nx35538
+ S0=nx34850
Xix23649 aoi22 $PINS Y=nx23648 A0=camera_module_cache_ram_36__6 A1=nx37034
+ B0=camera_module_cache_ram_52__6 B1=nx37036
Xcamera_module_cache_reg_ram_36__6 dffr $PINS Q=camera_module_cache_ram_36__6
+ QB=#dummy[93] D=nx18573 CLK=clk R=rst
Xix18574 mux21_ni $PINS Y=nx18573 A0=camera_module_cache_ram_36__6 A1=nx35538
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__6 dffr $PINS Q=camera_module_cache_ram_52__6
+ QB=#dummy[94] D=nx18563 CLK=clk R=rst
Xix18564 mux21_ni $PINS Y=nx18563 A0=camera_module_cache_ram_52__6 A1=nx35538
+ S0=nx34842
Xix23661 aoi22 $PINS Y=nx23660 A0=camera_module_cache_ram_68__6 A1=nx37038
+ B0=camera_module_cache_ram_84__6 B1=nx37040
Xcamera_module_cache_reg_ram_68__6 dffr $PINS Q=camera_module_cache_ram_68__6
+ QB=#dummy[95] D=nx18553 CLK=clk R=rst
Xix18554 mux21_ni $PINS Y=nx18553 A0=camera_module_cache_ram_68__6 A1=nx35538
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__6 dffr $PINS Q=camera_module_cache_ram_84__6
+ QB=#dummy[96] D=nx18543 CLK=clk R=rst
Xix18544 mux21_ni $PINS Y=nx18543 A0=camera_module_cache_ram_84__6 A1=nx35538
+ S0=nx34834
Xix23671 aoi22 $PINS Y=nx23670 A0=camera_module_cache_ram_116__6 A1=nx37042
+ B0=camera_module_cache_ram_100__6 B1=nx37044
Xcamera_module_cache_reg_ram_116__6 dffr $PINS Q=camera_module_cache_ram_116__6
+ QB=#dummy[97] D=nx18523 CLK=clk R=rst
Xix18524 mux21_ni $PINS Y=nx18523 A0=camera_module_cache_ram_116__6 A1=nx35540
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__6 dffr $PINS Q=camera_module_cache_ram_100__6
+ QB=#dummy[98] D=nx18533 CLK=clk R=rst
Xix18534 mux21_ni $PINS Y=nx18533 A0=camera_module_cache_ram_100__6 A1=nx35540
+ S0=nx34830
Xix21847 nand04 $PINS Y=nx21846 A0=nx23683 A1=nx23695 A2=nx23706 A3=nx23719
Xix23684 aoi22 $PINS Y=nx23683 A0=camera_module_cache_ram_132__6 A1=nx37046
+ B0=camera_module_cache_ram_148__6 B1=nx37048
Xcamera_module_cache_reg_ram_132__6 dffr $PINS Q=camera_module_cache_ram_132__6
+ QB=#dummy[99] D=nx18513 CLK=clk R=rst
Xix18514 mux21_ni $PINS Y=nx18513 A0=camera_module_cache_ram_132__6 A1=nx35540
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__6 dffr $PINS Q=camera_module_cache_ram_148__6
+ QB=#dummy[100] D=nx18503 CLK=clk R=rst
Xix18504 mux21_ni $PINS Y=nx18503 A0=camera_module_cache_ram_148__6 A1=nx35540
+ S0=nx34818
Xix23696 aoi22 $PINS Y=nx23695 A0=camera_module_cache_ram_180__6 A1=nx37050
+ B0=camera_module_cache_ram_164__6 B1=nx37052
Xcamera_module_cache_reg_ram_180__6 dffr $PINS Q=camera_module_cache_ram_180__6
+ QB=#dummy[101] D=nx18483 CLK=clk R=rst
Xix18484 mux21_ni $PINS Y=nx18483 A0=camera_module_cache_ram_180__6 A1=nx35540
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__6 dffr $PINS Q=camera_module_cache_ram_164__6
+ QB=#dummy[102] D=nx18493 CLK=clk R=rst
Xix18494 mux21_ni $PINS Y=nx18493 A0=camera_module_cache_ram_164__6 A1=nx35540
+ S0=nx34814
Xix23707 aoi22 $PINS Y=nx23706 A0=camera_module_cache_ram_196__6 A1=nx36288
+ B0=camera_module_cache_ram_212__6 B1=nx36328
Xcamera_module_cache_reg_ram_196__6 dffr $PINS Q=camera_module_cache_ram_196__6
+ QB=#dummy[103] D=nx18473 CLK=clk R=rst
Xix18474 mux21_ni $PINS Y=nx18473 A0=camera_module_cache_ram_196__6 A1=nx35540
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__6 dffr $PINS Q=camera_module_cache_ram_212__6
+ QB=#dummy[104] D=nx18463 CLK=clk R=rst
Xix18464 mux21_ni $PINS Y=nx18463 A0=camera_module_cache_ram_212__6 A1=nx35542
+ S0=nx34802
Xix23720 aoi22 $PINS Y=nx23719 A0=camera_module_cache_ram_228__6 A1=nx36368
+ B0=camera_module_cache_ram_244__6 B1=nx36408
Xcamera_module_cache_reg_ram_228__6 dffr $PINS Q=camera_module_cache_ram_228__6
+ QB=#dummy[105] D=nx18453 CLK=clk R=rst
Xix18454 mux21_ni $PINS Y=nx18453 A0=camera_module_cache_ram_228__6 A1=nx35542
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__6 dffr $PINS Q=camera_module_cache_ram_244__6
+ QB=#dummy[106] D=nx18443 CLK=clk R=rst
Xix18444 mux21_ni $PINS Y=nx18443 A0=camera_module_cache_ram_244__6 A1=nx35542
+ S0=nx34794
Xix23734 oai21 $PINS Y=nx23733 A0=nx21762 A1=nx21684 B0=nx36468
Xix21763 nand04 $PINS Y=nx21762 A0=nx23736 A1=nx23748 A2=nx23761 A3=nx23772
Xix23737 aoi22 $PINS Y=nx23736 A0=camera_module_cache_ram_5__6 A1=nx37030
+ B0=camera_module_cache_ram_21__6 B1=nx37032
Xcamera_module_cache_reg_ram_5__6 dffr $PINS Q=camera_module_cache_ram_5__6
+ QB=#dummy[107] D=nx18433 CLK=clk R=rst
Xix18434 mux21_ni $PINS Y=nx18433 A0=camera_module_cache_ram_5__6 A1=nx35542
+ S0=nx34784
Xix4183 nand02 $PINS Y=nx4182 A0=nx23639 A1=nx23314
Xcamera_module_cache_reg_ram_21__6 dffr $PINS Q=camera_module_cache_ram_21__6
+ QB=#dummy[108] D=nx18423 CLK=clk R=rst
Xix18424 mux21_ni $PINS Y=nx18423 A0=camera_module_cache_ram_21__6 A1=nx35542
+ S0=nx34780
Xix23749 aoi22 $PINS Y=nx23748 A0=camera_module_cache_ram_37__6 A1=nx37034
+ B0=camera_module_cache_ram_53__6 B1=nx37036
Xcamera_module_cache_reg_ram_37__6 dffr $PINS Q=camera_module_cache_ram_37__6
+ QB=#dummy[109] D=nx18413 CLK=clk R=rst
Xix18414 mux21_ni $PINS Y=nx18413 A0=camera_module_cache_ram_37__6 A1=nx35542
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__6 dffr $PINS Q=camera_module_cache_ram_53__6
+ QB=#dummy[110] D=nx18403 CLK=clk R=rst
Xix18404 mux21_ni $PINS Y=nx18403 A0=camera_module_cache_ram_53__6 A1=nx35542
+ S0=nx34772
Xix23762 aoi22 $PINS Y=nx23761 A0=camera_module_cache_ram_69__6 A1=nx37038
+ B0=camera_module_cache_ram_85__6 B1=nx37040
Xcamera_module_cache_reg_ram_69__6 dffr $PINS Q=camera_module_cache_ram_69__6
+ QB=#dummy[111] D=nx18393 CLK=clk R=rst
Xix18394 mux21_ni $PINS Y=nx18393 A0=camera_module_cache_ram_69__6 A1=nx35544
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__6 dffr $PINS Q=camera_module_cache_ram_85__6
+ QB=#dummy[112] D=nx18383 CLK=clk R=rst
Xix18384 mux21_ni $PINS Y=nx18383 A0=camera_module_cache_ram_85__6 A1=nx35544
+ S0=nx34764
Xix23773 aoi22 $PINS Y=nx23772 A0=camera_module_cache_ram_117__6 A1=nx37042
+ B0=camera_module_cache_ram_101__6 B1=nx37044
Xcamera_module_cache_reg_ram_117__6 dffr $PINS Q=camera_module_cache_ram_117__6
+ QB=#dummy[113] D=nx18363 CLK=clk R=rst
Xix18364 mux21_ni $PINS Y=nx18363 A0=camera_module_cache_ram_117__6 A1=nx35544
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__6 dffr $PINS Q=camera_module_cache_ram_101__6
+ QB=#dummy[114] D=nx18373 CLK=clk R=rst
Xix18374 mux21_ni $PINS Y=nx18373 A0=camera_module_cache_ram_101__6 A1=nx35544
+ S0=nx34760
Xix21685 nand04 $PINS Y=nx21684 A0=nx23785 A1=nx23797 A2=nx23811 A3=nx23822
Xix23786 aoi22 $PINS Y=nx23785 A0=camera_module_cache_ram_133__6 A1=nx37046
+ B0=camera_module_cache_ram_149__6 B1=nx37048
Xcamera_module_cache_reg_ram_133__6 dffr $PINS Q=camera_module_cache_ram_133__6
+ QB=#dummy[115] D=nx18353 CLK=clk R=rst
Xix18354 mux21_ni $PINS Y=nx18353 A0=camera_module_cache_ram_133__6 A1=nx35544
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__6 dffr $PINS Q=camera_module_cache_ram_149__6
+ QB=#dummy[116] D=nx18343 CLK=clk R=rst
Xix18344 mux21_ni $PINS Y=nx18343 A0=camera_module_cache_ram_149__6 A1=nx35544
+ S0=nx34748
Xix23798 aoi22 $PINS Y=nx23797 A0=camera_module_cache_ram_181__6 A1=nx37050
+ B0=camera_module_cache_ram_165__6 B1=nx37052
Xcamera_module_cache_reg_ram_181__6 dffr $PINS Q=camera_module_cache_ram_181__6
+ QB=#dummy[117] D=nx18323 CLK=clk R=rst
Xix18324 mux21_ni $PINS Y=nx18323 A0=camera_module_cache_ram_181__6 A1=nx35544
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__6 dffr $PINS Q=camera_module_cache_ram_165__6
+ QB=#dummy[118] D=nx18333 CLK=clk R=rst
Xix18334 mux21_ni $PINS Y=nx18333 A0=camera_module_cache_ram_165__6 A1=nx35546
+ S0=nx34744
Xix23812 aoi22 $PINS Y=nx23811 A0=camera_module_cache_ram_197__6 A1=nx36288
+ B0=camera_module_cache_ram_213__6 B1=nx36328
Xcamera_module_cache_reg_ram_197__6 dffr $PINS Q=camera_module_cache_ram_197__6
+ QB=#dummy[119] D=nx18313 CLK=clk R=rst
Xix18314 mux21_ni $PINS Y=nx18313 A0=camera_module_cache_ram_197__6 A1=nx35546
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__6 dffr $PINS Q=camera_module_cache_ram_213__6
+ QB=#dummy[120] D=nx18303 CLK=clk R=rst
Xix18304 mux21_ni $PINS Y=nx18303 A0=camera_module_cache_ram_213__6 A1=nx35546
+ S0=nx34732
Xix23823 aoi22 $PINS Y=nx23822 A0=camera_module_cache_ram_229__6 A1=nx36368
+ B0=camera_module_cache_ram_245__6 B1=nx36408
Xcamera_module_cache_reg_ram_229__6 dffr $PINS Q=camera_module_cache_ram_229__6
+ QB=#dummy[121] D=nx18293 CLK=clk R=rst
Xix18294 mux21_ni $PINS Y=nx18293 A0=camera_module_cache_ram_229__6 A1=nx35546
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__6 dffr $PINS Q=camera_module_cache_ram_245__6
+ QB=#dummy[122] D=nx18283 CLK=clk R=rst
Xix18284 mux21_ni $PINS Y=nx18283 A0=camera_module_cache_ram_245__6 A1=nx35546
+ S0=nx34724
Xix23836 oai21 $PINS Y=nx23835 A0=nx21598 A1=nx21520 B0=nx36472
Xix21599 nand04 $PINS Y=nx21598 A0=nx23839 A1=nx23852 A2=nx23863 A3=nx23875
Xix23840 aoi22 $PINS Y=nx23839 A0=camera_module_cache_ram_6__6 A1=nx37030
+ B0=camera_module_cache_ram_22__6 B1=nx37032
Xcamera_module_cache_reg_ram_6__6 dffr $PINS Q=camera_module_cache_ram_6__6
+ QB=#dummy[123] D=nx18273 CLK=clk R=rst
Xix18274 mux21_ni $PINS Y=nx18273 A0=camera_module_cache_ram_6__6 A1=nx35546
+ S0=nx34714
Xix3889 nand02 $PINS Y=nx3888 A0=nx23639 A1=nx23423
Xcamera_module_cache_reg_ram_22__6 dffr $PINS Q=camera_module_cache_ram_22__6
+ QB=#dummy[124] D=nx18263 CLK=clk R=rst
Xix18264 mux21_ni $PINS Y=nx18263 A0=camera_module_cache_ram_22__6 A1=nx35546
+ S0=nx34710
Xix23853 aoi22 $PINS Y=nx23852 A0=camera_module_cache_ram_38__6 A1=nx37034
+ B0=camera_module_cache_ram_54__6 B1=nx37036
Xcamera_module_cache_reg_ram_38__6 dffr $PINS Q=camera_module_cache_ram_38__6
+ QB=#dummy[125] D=nx18253 CLK=clk R=rst
Xix18254 mux21_ni $PINS Y=nx18253 A0=camera_module_cache_ram_38__6 A1=nx35548
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__6 dffr $PINS Q=camera_module_cache_ram_54__6
+ QB=#dummy[126] D=nx18243 CLK=clk R=rst
Xix18244 mux21_ni $PINS Y=nx18243 A0=camera_module_cache_ram_54__6 A1=nx35548
+ S0=nx34702
Xix23864 aoi22 $PINS Y=nx23863 A0=camera_module_cache_ram_70__6 A1=nx37038
+ B0=camera_module_cache_ram_86__6 B1=nx37040
Xcamera_module_cache_reg_ram_70__6 dffr $PINS Q=camera_module_cache_ram_70__6
+ QB=#dummy[127] D=nx18233 CLK=clk R=rst
Xix18234 mux21_ni $PINS Y=nx18233 A0=camera_module_cache_ram_70__6 A1=nx35548
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__6 dffr $PINS Q=camera_module_cache_ram_86__6
+ QB=#dummy[128] D=nx18223 CLK=clk R=rst
Xix18224 mux21_ni $PINS Y=nx18223 A0=camera_module_cache_ram_86__6 A1=nx35548
+ S0=nx34694
Xix23876 aoi22 $PINS Y=nx23875 A0=camera_module_cache_ram_118__6 A1=nx37042
+ B0=camera_module_cache_ram_102__6 B1=nx37044
Xcamera_module_cache_reg_ram_118__6 dffr $PINS Q=camera_module_cache_ram_118__6
+ QB=#dummy[129] D=nx18203 CLK=clk R=rst
Xix18204 mux21_ni $PINS Y=nx18203 A0=camera_module_cache_ram_118__6 A1=nx35548
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__6 dffr $PINS Q=camera_module_cache_ram_102__6
+ QB=#dummy[130] D=nx18213 CLK=clk R=rst
Xix18214 mux21_ni $PINS Y=nx18213 A0=camera_module_cache_ram_102__6 A1=nx35548
+ S0=nx34690
Xix21521 nand04 $PINS Y=nx21520 A0=nx23889 A1=nx23900 A2=nx23913 A3=nx23925
Xix23890 aoi22 $PINS Y=nx23889 A0=camera_module_cache_ram_134__6 A1=nx37046
+ B0=camera_module_cache_ram_150__6 B1=nx37048
Xcamera_module_cache_reg_ram_134__6 dffr $PINS Q=camera_module_cache_ram_134__6
+ QB=#dummy[131] D=nx18193 CLK=clk R=rst
Xix18194 mux21_ni $PINS Y=nx18193 A0=camera_module_cache_ram_134__6 A1=nx35548
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__6 dffr $PINS Q=camera_module_cache_ram_150__6
+ QB=#dummy[132] D=nx18183 CLK=clk R=rst
Xix18184 mux21_ni $PINS Y=nx18183 A0=camera_module_cache_ram_150__6 A1=nx35550
+ S0=nx34678
Xix23901 aoi22 $PINS Y=nx23900 A0=camera_module_cache_ram_182__6 A1=nx37050
+ B0=camera_module_cache_ram_166__6 B1=nx37052
Xcamera_module_cache_reg_ram_182__6 dffr $PINS Q=camera_module_cache_ram_182__6
+ QB=#dummy[133] D=nx18163 CLK=clk R=rst
Xix18164 mux21_ni $PINS Y=nx18163 A0=camera_module_cache_ram_182__6 A1=nx35550
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__6 dffr $PINS Q=camera_module_cache_ram_166__6
+ QB=#dummy[134] D=nx18173 CLK=clk R=rst
Xix18174 mux21_ni $PINS Y=nx18173 A0=camera_module_cache_ram_166__6 A1=nx35550
+ S0=nx34674
Xix23914 aoi22 $PINS Y=nx23913 A0=camera_module_cache_ram_198__6 A1=nx36288
+ B0=camera_module_cache_ram_214__6 B1=nx36328
Xcamera_module_cache_reg_ram_198__6 dffr $PINS Q=camera_module_cache_ram_198__6
+ QB=#dummy[135] D=nx18153 CLK=clk R=rst
Xix18154 mux21_ni $PINS Y=nx18153 A0=camera_module_cache_ram_198__6 A1=nx35550
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__6 dffr $PINS Q=camera_module_cache_ram_214__6
+ QB=#dummy[136] D=nx18143 CLK=clk R=rst
Xix18144 mux21_ni $PINS Y=nx18143 A0=camera_module_cache_ram_214__6 A1=nx35550
+ S0=nx34662
Xix23926 aoi22 $PINS Y=nx23925 A0=camera_module_cache_ram_230__6 A1=nx36368
+ B0=camera_module_cache_ram_246__6 B1=nx36408
Xcamera_module_cache_reg_ram_230__6 dffr $PINS Q=camera_module_cache_ram_230__6
+ QB=#dummy[137] D=nx18133 CLK=clk R=rst
Xix18134 mux21_ni $PINS Y=nx18133 A0=camera_module_cache_ram_230__6 A1=nx35550
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__6 dffr $PINS Q=camera_module_cache_ram_246__6
+ QB=#dummy[138] D=nx18123 CLK=clk R=rst
Xix18124 mux21_ni $PINS Y=nx18123 A0=camera_module_cache_ram_246__6 A1=nx35550
+ S0=nx34654
Xix23939 oai21 $PINS Y=nx23938 A0=nx21436 A1=nx21358 B0=nx36476
Xix21437 nand04 $PINS Y=nx21436 A0=nx23941 A1=nx23954 A2=nx23966 A3=nx23977
Xix23942 aoi22 $PINS Y=nx23941 A0=camera_module_cache_ram_7__6 A1=nx35810
+ B0=camera_module_cache_ram_23__6 B1=nx35850
Xcamera_module_cache_reg_ram_7__6 dffr $PINS Q=camera_module_cache_ram_7__6
+ QB=#dummy[139] D=nx18113 CLK=clk R=rst
Xix18114 mux21_ni $PINS Y=nx18113 A0=camera_module_cache_ram_7__6 A1=nx35552
+ S0=nx34644
Xix3597 nand02 $PINS Y=nx3596 A0=nx23639 A1=nx23529
Xcamera_module_cache_reg_ram_23__6 dffr $PINS Q=camera_module_cache_ram_23__6
+ QB=#dummy[140] D=nx18103 CLK=clk R=rst
Xix18104 mux21_ni $PINS Y=nx18103 A0=camera_module_cache_ram_23__6 A1=nx35552
+ S0=nx34640
Xix23955 aoi22 $PINS Y=nx23954 A0=camera_module_cache_ram_39__6 A1=nx35890
+ B0=camera_module_cache_ram_55__6 B1=nx35930
Xcamera_module_cache_reg_ram_39__6 dffr $PINS Q=camera_module_cache_ram_39__6
+ QB=#dummy[141] D=nx18093 CLK=clk R=rst
Xix18094 mux21_ni $PINS Y=nx18093 A0=camera_module_cache_ram_39__6 A1=nx35552
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__6 dffr $PINS Q=camera_module_cache_ram_55__6
+ QB=#dummy[142] D=nx18083 CLK=clk R=rst
Xix18084 mux21_ni $PINS Y=nx18083 A0=camera_module_cache_ram_55__6 A1=nx35552
+ S0=nx34632
Xix23967 aoi22 $PINS Y=nx23966 A0=camera_module_cache_ram_71__6 A1=nx35970
+ B0=camera_module_cache_ram_87__6 B1=nx36010
Xcamera_module_cache_reg_ram_71__6 dffr $PINS Q=camera_module_cache_ram_71__6
+ QB=#dummy[143] D=nx18073 CLK=clk R=rst
Xix18074 mux21_ni $PINS Y=nx18073 A0=camera_module_cache_ram_71__6 A1=nx35552
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__6 dffr $PINS Q=camera_module_cache_ram_87__6
+ QB=#dummy[144] D=nx18063 CLK=clk R=rst
Xix18064 mux21_ni $PINS Y=nx18063 A0=camera_module_cache_ram_87__6 A1=nx35552
+ S0=nx34624
Xix23978 aoi22 $PINS Y=nx23977 A0=camera_module_cache_ram_119__6 A1=nx36050
+ B0=camera_module_cache_ram_103__6 B1=nx36090
Xcamera_module_cache_reg_ram_119__6 dffr $PINS Q=camera_module_cache_ram_119__6
+ QB=#dummy[145] D=nx18043 CLK=clk R=rst
Xix18044 mux21_ni $PINS Y=nx18043 A0=camera_module_cache_ram_119__6 A1=nx35552
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__6 dffr $PINS Q=camera_module_cache_ram_103__6
+ QB=#dummy[146] D=nx18053 CLK=clk R=rst
Xix18054 mux21_ni $PINS Y=nx18053 A0=camera_module_cache_ram_103__6 A1=nx35554
+ S0=nx34620
Xix21359 nand04 $PINS Y=nx21358 A0=nx23989 A1=nx24001 A2=nx24012 A3=nx24024
Xix23990 aoi22 $PINS Y=nx23989 A0=camera_module_cache_ram_135__6 A1=nx36130
+ B0=camera_module_cache_ram_151__6 B1=nx36170
Xcamera_module_cache_reg_ram_135__6 dffr $PINS Q=camera_module_cache_ram_135__6
+ QB=#dummy[147] D=nx18033 CLK=clk R=rst
Xix18034 mux21_ni $PINS Y=nx18033 A0=camera_module_cache_ram_135__6 A1=nx35554
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__6 dffr $PINS Q=camera_module_cache_ram_151__6
+ QB=#dummy[148] D=nx18023 CLK=clk R=rst
Xix18024 mux21_ni $PINS Y=nx18023 A0=camera_module_cache_ram_151__6 A1=nx35554
+ S0=nx34608
Xix24002 aoi22 $PINS Y=nx24001 A0=camera_module_cache_ram_183__6 A1=nx36210
+ B0=camera_module_cache_ram_167__6 B1=nx36250
Xcamera_module_cache_reg_ram_183__6 dffr $PINS Q=camera_module_cache_ram_183__6
+ QB=#dummy[149] D=nx18003 CLK=clk R=rst
Xix18004 mux21_ni $PINS Y=nx18003 A0=camera_module_cache_ram_183__6 A1=nx35554
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__6 dffr $PINS Q=camera_module_cache_ram_167__6
+ QB=#dummy[150] D=nx18013 CLK=clk R=rst
Xix18014 mux21_ni $PINS Y=nx18013 A0=camera_module_cache_ram_167__6 A1=nx35554
+ S0=nx34604
Xix24013 aoi22 $PINS Y=nx24012 A0=camera_module_cache_ram_199__6 A1=nx36290
+ B0=camera_module_cache_ram_215__6 B1=nx36330
Xcamera_module_cache_reg_ram_199__6 dffr $PINS Q=camera_module_cache_ram_199__6
+ QB=#dummy[151] D=nx17993 CLK=clk R=rst
Xix17994 mux21_ni $PINS Y=nx17993 A0=camera_module_cache_ram_199__6 A1=nx35554
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__6 dffr $PINS Q=camera_module_cache_ram_215__6
+ QB=#dummy[152] D=nx17983 CLK=clk R=rst
Xix17984 mux21_ni $PINS Y=nx17983 A0=camera_module_cache_ram_215__6 A1=nx35554
+ S0=nx34592
Xix24025 aoi22 $PINS Y=nx24024 A0=camera_module_cache_ram_231__6 A1=nx36370
+ B0=camera_module_cache_ram_247__6 B1=nx36410
Xcamera_module_cache_reg_ram_231__6 dffr $PINS Q=camera_module_cache_ram_231__6
+ QB=#dummy[153] D=nx17973 CLK=clk R=rst
Xix17974 mux21_ni $PINS Y=nx17973 A0=camera_module_cache_ram_231__6 A1=nx35556
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__6 dffr $PINS Q=camera_module_cache_ram_247__6
+ QB=#dummy[154] D=nx17963 CLK=clk R=rst
Xix17964 mux21_ni $PINS Y=nx17963 A0=camera_module_cache_ram_247__6 A1=nx35556
+ S0=nx34584
Xix21279 nand04 $PINS Y=nx21278 A0=nx24041 A1=nx24146 A2=nx24248 A3=nx24349
Xix24042 oai21 $PINS Y=nx24041 A0=nx21268 A1=nx21190 B0=nx36480
Xix21269 nand04 $PINS Y=nx21268 A0=nx24045 A1=nx24060 A2=nx24073 A3=nx24084
Xix24046 aoi22 $PINS Y=nx24045 A0=camera_module_cache_ram_8__6 A1=nx35810
+ B0=camera_module_cache_ram_24__6 B1=nx35850
Xcamera_module_cache_reg_ram_8__6 dffr $PINS Q=camera_module_cache_ram_8__6
+ QB=#dummy[155] D=nx17953 CLK=clk R=rst
Xix17954 mux21_ni $PINS Y=nx17953 A0=camera_module_cache_ram_8__6 A1=nx35556
+ S0=nx34574
Xix3295 nand02 $PINS Y=nx3294 A0=nx24053 A1=nx23105
Xcamera_module_cache_reg_ram_24__6 dffr $PINS Q=camera_module_cache_ram_24__6
+ QB=#dummy[156] D=nx17943 CLK=clk R=rst
Xix17944 mux21_ni $PINS Y=nx17943 A0=camera_module_cache_ram_24__6 A1=nx35556
+ S0=nx34570
Xix24061 aoi22 $PINS Y=nx24060 A0=camera_module_cache_ram_40__6 A1=nx35890
+ B0=camera_module_cache_ram_56__6 B1=nx35930
Xcamera_module_cache_reg_ram_40__6 dffr $PINS Q=camera_module_cache_ram_40__6
+ QB=#dummy[157] D=nx17933 CLK=clk R=rst
Xix17934 mux21_ni $PINS Y=nx17933 A0=camera_module_cache_ram_40__6 A1=nx35556
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__6 dffr $PINS Q=camera_module_cache_ram_56__6
+ QB=#dummy[158] D=nx17923 CLK=clk R=rst
Xix17924 mux21_ni $PINS Y=nx17923 A0=camera_module_cache_ram_56__6 A1=nx35556
+ S0=nx34562
Xix24074 aoi22 $PINS Y=nx24073 A0=camera_module_cache_ram_72__6 A1=nx35970
+ B0=camera_module_cache_ram_88__6 B1=nx36010
Xcamera_module_cache_reg_ram_72__6 dffr $PINS Q=camera_module_cache_ram_72__6
+ QB=#dummy[159] D=nx17913 CLK=clk R=rst
Xix17914 mux21_ni $PINS Y=nx17913 A0=camera_module_cache_ram_72__6 A1=nx35556
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__6 dffr $PINS Q=camera_module_cache_ram_88__6
+ QB=#dummy[160] D=nx17903 CLK=clk R=rst
Xix17904 mux21_ni $PINS Y=nx17903 A0=camera_module_cache_ram_88__6 A1=nx35558
+ S0=nx34554
Xix24085 aoi22 $PINS Y=nx24084 A0=camera_module_cache_ram_120__6 A1=nx36050
+ B0=camera_module_cache_ram_104__6 B1=nx36090
Xcamera_module_cache_reg_ram_120__6 dffr $PINS Q=camera_module_cache_ram_120__6
+ QB=#dummy[161] D=nx17883 CLK=clk R=rst
Xix17884 mux21_ni $PINS Y=nx17883 A0=camera_module_cache_ram_120__6 A1=nx35558
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__6 dffr $PINS Q=camera_module_cache_ram_104__6
+ QB=#dummy[162] D=nx17893 CLK=clk R=rst
Xix17894 mux21_ni $PINS Y=nx17893 A0=camera_module_cache_ram_104__6 A1=nx35558
+ S0=nx34550
Xix21191 nand04 $PINS Y=nx21190 A0=nx24097 A1=nx24109 A2=nx24120 A3=nx24133
Xix24098 aoi22 $PINS Y=nx24097 A0=camera_module_cache_ram_136__6 A1=nx36130
+ B0=camera_module_cache_ram_152__6 B1=nx36170
Xcamera_module_cache_reg_ram_136__6 dffr $PINS Q=camera_module_cache_ram_136__6
+ QB=#dummy[163] D=nx17873 CLK=clk R=rst
Xix17874 mux21_ni $PINS Y=nx17873 A0=camera_module_cache_ram_136__6 A1=nx35558
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__6 dffr $PINS Q=camera_module_cache_ram_152__6
+ QB=#dummy[164] D=nx17863 CLK=clk R=rst
Xix17864 mux21_ni $PINS Y=nx17863 A0=camera_module_cache_ram_152__6 A1=nx35558
+ S0=nx34538
Xix24110 aoi22 $PINS Y=nx24109 A0=camera_module_cache_ram_184__6 A1=nx36210
+ B0=camera_module_cache_ram_168__6 B1=nx36250
Xcamera_module_cache_reg_ram_184__6 dffr $PINS Q=camera_module_cache_ram_184__6
+ QB=#dummy[165] D=nx17843 CLK=clk R=rst
Xix17844 mux21_ni $PINS Y=nx17843 A0=camera_module_cache_ram_184__6 A1=nx35558
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__6 dffr $PINS Q=camera_module_cache_ram_168__6
+ QB=#dummy[166] D=nx17853 CLK=clk R=rst
Xix17854 mux21_ni $PINS Y=nx17853 A0=camera_module_cache_ram_168__6 A1=nx35558
+ S0=nx34534
Xix24121 aoi22 $PINS Y=nx24120 A0=camera_module_cache_ram_200__6 A1=nx36290
+ B0=camera_module_cache_ram_216__6 B1=nx36330
Xcamera_module_cache_reg_ram_200__6 dffr $PINS Q=camera_module_cache_ram_200__6
+ QB=#dummy[167] D=nx17833 CLK=clk R=rst
Xix17834 mux21_ni $PINS Y=nx17833 A0=camera_module_cache_ram_200__6 A1=nx35560
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__6 dffr $PINS Q=camera_module_cache_ram_216__6
+ QB=#dummy[168] D=nx17823 CLK=clk R=rst
Xix17824 mux21_ni $PINS Y=nx17823 A0=camera_module_cache_ram_216__6 A1=nx35560
+ S0=nx34522
Xix24134 aoi22 $PINS Y=nx24133 A0=camera_module_cache_ram_232__6 A1=nx36370
+ B0=camera_module_cache_ram_248__6 B1=nx36410
Xcamera_module_cache_reg_ram_232__6 dffr $PINS Q=camera_module_cache_ram_232__6
+ QB=#dummy[169] D=nx17813 CLK=clk R=rst
Xix17814 mux21_ni $PINS Y=nx17813 A0=camera_module_cache_ram_232__6 A1=nx35560
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__6 dffr $PINS Q=camera_module_cache_ram_248__6
+ QB=#dummy[170] D=nx17803 CLK=clk R=rst
Xix17804 mux21_ni $PINS Y=nx17803 A0=camera_module_cache_ram_248__6 A1=nx35560
+ S0=nx34514
Xix24147 oai21 $PINS Y=nx24146 A0=nx21106 A1=nx21028 B0=nx36484
Xix21107 nand04 $PINS Y=nx21106 A0=nx24149 A1=nx24162 A2=nx24174 A3=nx24184
Xix24150 aoi22 $PINS Y=nx24149 A0=camera_module_cache_ram_9__6 A1=nx35810
+ B0=camera_module_cache_ram_25__6 B1=nx35850
Xcamera_module_cache_reg_ram_9__6 dffr $PINS Q=camera_module_cache_ram_9__6
+ QB=#dummy[171] D=nx17793 CLK=clk R=rst
Xix17794 mux21_ni $PINS Y=nx17793 A0=camera_module_cache_ram_9__6 A1=nx35560
+ S0=nx34504
Xix3003 nand02 $PINS Y=nx3002 A0=nx24053 A1=nx23314
Xcamera_module_cache_reg_ram_25__6 dffr $PINS Q=camera_module_cache_ram_25__6
+ QB=#dummy[172] D=nx17783 CLK=clk R=rst
Xix17784 mux21_ni $PINS Y=nx17783 A0=camera_module_cache_ram_25__6 A1=nx35560
+ S0=nx34500
Xix24163 aoi22 $PINS Y=nx24162 A0=camera_module_cache_ram_41__6 A1=nx35890
+ B0=camera_module_cache_ram_57__6 B1=nx35930
Xcamera_module_cache_reg_ram_41__6 dffr $PINS Q=camera_module_cache_ram_41__6
+ QB=#dummy[173] D=nx17773 CLK=clk R=rst
Xix17774 mux21_ni $PINS Y=nx17773 A0=camera_module_cache_ram_41__6 A1=nx35560
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__6 dffr $PINS Q=camera_module_cache_ram_57__6
+ QB=#dummy[174] D=nx17763 CLK=clk R=rst
Xix17764 mux21_ni $PINS Y=nx17763 A0=camera_module_cache_ram_57__6 A1=nx35562
+ S0=nx34492
Xix24175 aoi22 $PINS Y=nx24174 A0=camera_module_cache_ram_73__6 A1=nx35970
+ B0=camera_module_cache_ram_89__6 B1=nx36010
Xcamera_module_cache_reg_ram_73__6 dffr $PINS Q=camera_module_cache_ram_73__6
+ QB=#dummy[175] D=nx17753 CLK=clk R=rst
Xix17754 mux21_ni $PINS Y=nx17753 A0=camera_module_cache_ram_73__6 A1=nx35562
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__6 dffr $PINS Q=camera_module_cache_ram_89__6
+ QB=#dummy[176] D=nx17743 CLK=clk R=rst
Xix17744 mux21_ni $PINS Y=nx17743 A0=camera_module_cache_ram_89__6 A1=nx35562
+ S0=nx34484
Xix24185 aoi22 $PINS Y=nx24184 A0=camera_module_cache_ram_121__6 A1=nx36050
+ B0=camera_module_cache_ram_105__6 B1=nx36090
Xcamera_module_cache_reg_ram_121__6 dffr $PINS Q=camera_module_cache_ram_121__6
+ QB=#dummy[177] D=nx17723 CLK=clk R=rst
Xix17724 mux21_ni $PINS Y=nx17723 A0=camera_module_cache_ram_121__6 A1=nx35562
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__6 dffr $PINS Q=camera_module_cache_ram_105__6
+ QB=#dummy[178] D=nx17733 CLK=clk R=rst
Xix17734 mux21_ni $PINS Y=nx17733 A0=camera_module_cache_ram_105__6 A1=nx35562
+ S0=nx34480
Xix21029 nand04 $PINS Y=nx21028 A0=nx24197 A1=nx24209 A2=nx24222 A3=nx24235
Xix24198 aoi22 $PINS Y=nx24197 A0=camera_module_cache_ram_137__6 A1=nx36130
+ B0=camera_module_cache_ram_153__6 B1=nx36170
Xcamera_module_cache_reg_ram_137__6 dffr $PINS Q=camera_module_cache_ram_137__6
+ QB=#dummy[179] D=nx17713 CLK=clk R=rst
Xix17714 mux21_ni $PINS Y=nx17713 A0=camera_module_cache_ram_137__6 A1=nx35562
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__6 dffr $PINS Q=camera_module_cache_ram_153__6
+ QB=#dummy[180] D=nx17703 CLK=clk R=rst
Xix17704 mux21_ni $PINS Y=nx17703 A0=camera_module_cache_ram_153__6 A1=nx35562
+ S0=nx34468
Xix24210 aoi22 $PINS Y=nx24209 A0=camera_module_cache_ram_185__6 A1=nx36210
+ B0=camera_module_cache_ram_169__6 B1=nx36250
Xcamera_module_cache_reg_ram_185__6 dffr $PINS Q=camera_module_cache_ram_185__6
+ QB=#dummy[181] D=nx17683 CLK=clk R=rst
Xix17684 mux21_ni $PINS Y=nx17683 A0=camera_module_cache_ram_185__6 A1=nx35564
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__6 dffr $PINS Q=camera_module_cache_ram_169__6
+ QB=#dummy[182] D=nx17693 CLK=clk R=rst
Xix17694 mux21_ni $PINS Y=nx17693 A0=camera_module_cache_ram_169__6 A1=nx35564
+ S0=nx34464
Xix24223 aoi22 $PINS Y=nx24222 A0=camera_module_cache_ram_201__6 A1=nx36290
+ B0=camera_module_cache_ram_217__6 B1=nx36330
Xcamera_module_cache_reg_ram_201__6 dffr $PINS Q=camera_module_cache_ram_201__6
+ QB=#dummy[183] D=nx17673 CLK=clk R=rst
Xix17674 mux21_ni $PINS Y=nx17673 A0=camera_module_cache_ram_201__6 A1=nx35564
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__6 dffr $PINS Q=camera_module_cache_ram_217__6
+ QB=#dummy[184] D=nx17663 CLK=clk R=rst
Xix17664 mux21_ni $PINS Y=nx17663 A0=camera_module_cache_ram_217__6 A1=nx35564
+ S0=nx34452
Xix24236 aoi22 $PINS Y=nx24235 A0=camera_module_cache_ram_233__6 A1=nx36370
+ B0=camera_module_cache_ram_249__6 B1=nx36410
Xcamera_module_cache_reg_ram_233__6 dffr $PINS Q=camera_module_cache_ram_233__6
+ QB=#dummy[185] D=nx17653 CLK=clk R=rst
Xix17654 mux21_ni $PINS Y=nx17653 A0=camera_module_cache_ram_233__6 A1=nx35564
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__6 dffr $PINS Q=camera_module_cache_ram_249__6
+ QB=#dummy[186] D=nx17643 CLK=clk R=rst
Xix17644 mux21_ni $PINS Y=nx17643 A0=camera_module_cache_ram_249__6 A1=nx35564
+ S0=nx34444
Xix24249 oai21 $PINS Y=nx24248 A0=nx20942 A1=nx20864 B0=nx36488
Xix20943 nand04 $PINS Y=nx20942 A0=nx24251 A1=nx24264 A2=nx24276 A3=nx24286
Xix24252 aoi22 $PINS Y=nx24251 A0=camera_module_cache_ram_10__6 A1=nx35810
+ B0=camera_module_cache_ram_26__6 B1=nx35850
Xcamera_module_cache_reg_ram_10__6 dffr $PINS Q=camera_module_cache_ram_10__6
+ QB=#dummy[187] D=nx17633 CLK=clk R=rst
Xix17634 mux21_ni $PINS Y=nx17633 A0=camera_module_cache_ram_10__6 A1=nx35564
+ S0=nx34434
Xix2709 nand02 $PINS Y=nx2708 A0=nx24053 A1=nx23423
Xcamera_module_cache_reg_ram_26__6 dffr $PINS Q=camera_module_cache_ram_26__6
+ QB=#dummy[188] D=nx17623 CLK=clk R=rst
Xix17624 mux21_ni $PINS Y=nx17623 A0=camera_module_cache_ram_26__6 A1=nx35566
+ S0=nx34430
Xix24265 aoi22 $PINS Y=nx24264 A0=camera_module_cache_ram_42__6 A1=nx35890
+ B0=camera_module_cache_ram_58__6 B1=nx35930
Xcamera_module_cache_reg_ram_42__6 dffr $PINS Q=camera_module_cache_ram_42__6
+ QB=#dummy[189] D=nx17613 CLK=clk R=rst
Xix17614 mux21_ni $PINS Y=nx17613 A0=camera_module_cache_ram_42__6 A1=nx35566
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__6 dffr $PINS Q=camera_module_cache_ram_58__6
+ QB=#dummy[190] D=nx17603 CLK=clk R=rst
Xix17604 mux21_ni $PINS Y=nx17603 A0=camera_module_cache_ram_58__6 A1=nx35566
+ S0=nx34422
Xix24277 aoi22 $PINS Y=nx24276 A0=camera_module_cache_ram_74__6 A1=nx35970
+ B0=camera_module_cache_ram_90__6 B1=nx36010
Xcamera_module_cache_reg_ram_74__6 dffr $PINS Q=camera_module_cache_ram_74__6
+ QB=#dummy[191] D=nx17593 CLK=clk R=rst
Xix17594 mux21_ni $PINS Y=nx17593 A0=camera_module_cache_ram_74__6 A1=nx35566
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__6 dffr $PINS Q=camera_module_cache_ram_90__6
+ QB=#dummy[192] D=nx17583 CLK=clk R=rst
Xix17584 mux21_ni $PINS Y=nx17583 A0=camera_module_cache_ram_90__6 A1=nx35566
+ S0=nx34414
Xix24287 aoi22 $PINS Y=nx24286 A0=camera_module_cache_ram_122__6 A1=nx36050
+ B0=camera_module_cache_ram_106__6 B1=nx36090
Xcamera_module_cache_reg_ram_122__6 dffr $PINS Q=camera_module_cache_ram_122__6
+ QB=#dummy[193] D=nx17563 CLK=clk R=rst
Xix17564 mux21_ni $PINS Y=nx17563 A0=camera_module_cache_ram_122__6 A1=nx35566
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__6 dffr $PINS Q=camera_module_cache_ram_106__6
+ QB=#dummy[194] D=nx17573 CLK=clk R=rst
Xix17574 mux21_ni $PINS Y=nx17573 A0=camera_module_cache_ram_106__6 A1=nx35566
+ S0=nx34410
Xix20865 nand04 $PINS Y=nx20864 A0=nx24300 A1=nx24313 A2=nx24324 A3=nx24336
Xix24301 aoi22 $PINS Y=nx24300 A0=camera_module_cache_ram_138__6 A1=nx36130
+ B0=camera_module_cache_ram_154__6 B1=nx36170
Xcamera_module_cache_reg_ram_138__6 dffr $PINS Q=camera_module_cache_ram_138__6
+ QB=#dummy[195] D=nx17553 CLK=clk R=rst
Xix17554 mux21_ni $PINS Y=nx17553 A0=camera_module_cache_ram_138__6 A1=nx35568
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__6 dffr $PINS Q=camera_module_cache_ram_154__6
+ QB=#dummy[196] D=nx17543 CLK=clk R=rst
Xix17544 mux21_ni $PINS Y=nx17543 A0=camera_module_cache_ram_154__6 A1=nx35568
+ S0=nx34398
Xix24314 aoi22 $PINS Y=nx24313 A0=camera_module_cache_ram_186__6 A1=nx36210
+ B0=camera_module_cache_ram_170__6 B1=nx36250
Xcamera_module_cache_reg_ram_186__6 dffr $PINS Q=camera_module_cache_ram_186__6
+ QB=#dummy[197] D=nx17523 CLK=clk R=rst
Xix17524 mux21_ni $PINS Y=nx17523 A0=camera_module_cache_ram_186__6 A1=nx35568
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__6 dffr $PINS Q=camera_module_cache_ram_170__6
+ QB=#dummy[198] D=nx17533 CLK=clk R=rst
Xix17534 mux21_ni $PINS Y=nx17533 A0=camera_module_cache_ram_170__6 A1=nx35568
+ S0=nx34394
Xix24325 aoi22 $PINS Y=nx24324 A0=camera_module_cache_ram_202__6 A1=nx36290
+ B0=camera_module_cache_ram_218__6 B1=nx36330
Xcamera_module_cache_reg_ram_202__6 dffr $PINS Q=camera_module_cache_ram_202__6
+ QB=#dummy[199] D=nx17513 CLK=clk R=rst
Xix17514 mux21_ni $PINS Y=nx17513 A0=camera_module_cache_ram_202__6 A1=nx35568
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__6 dffr $PINS Q=camera_module_cache_ram_218__6
+ QB=#dummy[200] D=nx17503 CLK=clk R=rst
Xix17504 mux21_ni $PINS Y=nx17503 A0=camera_module_cache_ram_218__6 A1=nx35568
+ S0=nx34382
Xix24337 aoi22 $PINS Y=nx24336 A0=camera_module_cache_ram_234__6 A1=nx36370
+ B0=camera_module_cache_ram_250__6 B1=nx36410
Xcamera_module_cache_reg_ram_234__6 dffr $PINS Q=camera_module_cache_ram_234__6
+ QB=#dummy[201] D=nx17493 CLK=clk R=rst
Xix17494 mux21_ni $PINS Y=nx17493 A0=camera_module_cache_ram_234__6 A1=nx35568
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__6 dffr $PINS Q=camera_module_cache_ram_250__6
+ QB=#dummy[202] D=nx17483 CLK=clk R=rst
Xix17484 mux21_ni $PINS Y=nx17483 A0=camera_module_cache_ram_250__6 A1=nx35570
+ S0=nx34374
Xix24350 oai21 $PINS Y=nx24349 A0=nx20780 A1=nx20702 B0=nx36492
Xix20781 nand04 $PINS Y=nx20780 A0=nx24353 A1=nx24364 A2=nx24379 A3=nx24390
Xix24354 aoi22 $PINS Y=nx24353 A0=camera_module_cache_ram_11__6 A1=nx35810
+ B0=camera_module_cache_ram_27__6 B1=nx35850
Xcamera_module_cache_reg_ram_11__6 dffr $PINS Q=camera_module_cache_ram_11__6
+ QB=#dummy[203] D=nx17473 CLK=clk R=rst
Xix17474 mux21_ni $PINS Y=nx17473 A0=camera_module_cache_ram_11__6 A1=nx35570
+ S0=nx34364
Xix2417 nand02 $PINS Y=nx2416 A0=nx24053 A1=nx23529
Xcamera_module_cache_reg_ram_27__6 dffr $PINS Q=camera_module_cache_ram_27__6
+ QB=#dummy[204] D=nx17463 CLK=clk R=rst
Xix17464 mux21_ni $PINS Y=nx17463 A0=camera_module_cache_ram_27__6 A1=nx35570
+ S0=nx34360
Xix24365 aoi22 $PINS Y=nx24364 A0=camera_module_cache_ram_43__6 A1=nx35890
+ B0=camera_module_cache_ram_59__6 B1=nx35930
Xcamera_module_cache_reg_ram_43__6 dffr $PINS Q=camera_module_cache_ram_43__6
+ QB=#dummy[205] D=nx17453 CLK=clk R=rst
Xix17454 mux21_ni $PINS Y=nx17453 A0=camera_module_cache_ram_43__6 A1=nx35570
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__6 dffr $PINS Q=camera_module_cache_ram_59__6
+ QB=#dummy[206] D=nx17443 CLK=clk R=rst
Xix17444 mux21_ni $PINS Y=nx17443 A0=camera_module_cache_ram_59__6 A1=nx35570
+ S0=nx34352
Xix24380 aoi22 $PINS Y=nx24379 A0=camera_module_cache_ram_75__6 A1=nx35970
+ B0=camera_module_cache_ram_91__6 B1=nx36010
Xcamera_module_cache_reg_ram_75__6 dffr $PINS Q=camera_module_cache_ram_75__6
+ QB=#dummy[207] D=nx17433 CLK=clk R=rst
Xix17434 mux21_ni $PINS Y=nx17433 A0=camera_module_cache_ram_75__6 A1=nx35570
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__6 dffr $PINS Q=camera_module_cache_ram_91__6
+ QB=#dummy[208] D=nx17423 CLK=clk R=rst
Xix17424 mux21_ni $PINS Y=nx17423 A0=camera_module_cache_ram_91__6 A1=nx35570
+ S0=nx34344
Xix24391 aoi22 $PINS Y=nx24390 A0=camera_module_cache_ram_123__6 A1=nx36050
+ B0=camera_module_cache_ram_107__6 B1=nx36090
Xcamera_module_cache_reg_ram_123__6 dffr $PINS Q=camera_module_cache_ram_123__6
+ QB=#dummy[209] D=nx17403 CLK=clk R=rst
Xix17404 mux21_ni $PINS Y=nx17403 A0=camera_module_cache_ram_123__6 A1=nx35572
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__6 dffr $PINS Q=camera_module_cache_ram_107__6
+ QB=#dummy[210] D=nx17413 CLK=clk R=rst
Xix17414 mux21_ni $PINS Y=nx17413 A0=camera_module_cache_ram_107__6 A1=nx35572
+ S0=nx34340
Xix20703 nand04 $PINS Y=nx20702 A0=nx24403 A1=nx24415 A2=nx24428 A3=nx24440
Xix24404 aoi22 $PINS Y=nx24403 A0=camera_module_cache_ram_139__6 A1=nx36130
+ B0=camera_module_cache_ram_155__6 B1=nx36170
Xcamera_module_cache_reg_ram_139__6 dffr $PINS Q=camera_module_cache_ram_139__6
+ QB=#dummy[211] D=nx17393 CLK=clk R=rst
Xix17394 mux21_ni $PINS Y=nx17393 A0=camera_module_cache_ram_139__6 A1=nx35572
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__6 dffr $PINS Q=camera_module_cache_ram_155__6
+ QB=#dummy[212] D=nx17383 CLK=clk R=rst
Xix17384 mux21_ni $PINS Y=nx17383 A0=camera_module_cache_ram_155__6 A1=nx35572
+ S0=nx34328
Xix24416 aoi22 $PINS Y=nx24415 A0=camera_module_cache_ram_187__6 A1=nx36210
+ B0=camera_module_cache_ram_171__6 B1=nx36250
Xcamera_module_cache_reg_ram_187__6 dffr $PINS Q=camera_module_cache_ram_187__6
+ QB=#dummy[213] D=nx17363 CLK=clk R=rst
Xix17364 mux21_ni $PINS Y=nx17363 A0=camera_module_cache_ram_187__6 A1=nx35572
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__6 dffr $PINS Q=camera_module_cache_ram_171__6
+ QB=#dummy[214] D=nx17373 CLK=clk R=rst
Xix17374 mux21_ni $PINS Y=nx17373 A0=camera_module_cache_ram_171__6 A1=nx35572
+ S0=nx34324
Xix24429 aoi22 $PINS Y=nx24428 A0=camera_module_cache_ram_203__6 A1=nx36290
+ B0=camera_module_cache_ram_219__6 B1=nx36330
Xcamera_module_cache_reg_ram_203__6 dffr $PINS Q=camera_module_cache_ram_203__6
+ QB=#dummy[215] D=nx17353 CLK=clk R=rst
Xix17354 mux21_ni $PINS Y=nx17353 A0=camera_module_cache_ram_203__6 A1=nx35572
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__6 dffr $PINS Q=camera_module_cache_ram_219__6
+ QB=#dummy[216] D=nx17343 CLK=clk R=rst
Xix17344 mux21_ni $PINS Y=nx17343 A0=camera_module_cache_ram_219__6 A1=nx35574
+ S0=nx34312
Xix24441 aoi22 $PINS Y=nx24440 A0=camera_module_cache_ram_235__6 A1=nx36370
+ B0=camera_module_cache_ram_251__6 B1=nx36410
Xcamera_module_cache_reg_ram_235__6 dffr $PINS Q=camera_module_cache_ram_235__6
+ QB=#dummy[217] D=nx17333 CLK=clk R=rst
Xix17334 mux21_ni $PINS Y=nx17333 A0=camera_module_cache_ram_235__6 A1=nx35574
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__6 dffr $PINS Q=camera_module_cache_ram_251__6
+ QB=#dummy[218] D=nx17323 CLK=clk R=rst
Xix17324 mux21_ni $PINS Y=nx17323 A0=camera_module_cache_ram_251__6 A1=nx35574
+ S0=nx34304
Xix20625 nand04 $PINS Y=nx20624 A0=nx24455 A1=nx24572 A2=nx24686 A3=nx24801
Xix24456 oai21 $PINS Y=nx24455 A0=nx20614 A1=nx20536 B0=nx36506
Xix20615 nand04 $PINS Y=nx20614 A0=nx24459 A1=nx24477 A2=nx24490 A3=nx24503
Xix24460 aoi22 $PINS Y=nx24459 A0=camera_module_cache_ram_12__6 A1=nx35810
+ B0=camera_module_cache_ram_28__6 B1=nx35850
Xcamera_module_cache_reg_ram_12__6 dffr $PINS Q=camera_module_cache_ram_12__6
+ QB=#dummy[219] D=nx17313 CLK=clk R=rst
Xix17314 mux21_ni $PINS Y=nx17313 A0=nx35574 A1=camera_module_cache_ram_12__6
+ S0=nx36496
Xix913 nand02 $PINS Y=nx912 A0=nx906 A1=nx880
Xcamera_module_cache_reg_ram_28__6 dffr $PINS Q=camera_module_cache_ram_28__6
+ QB=#dummy[220] D=nx17303 CLK=clk R=rst
Xix17304 mux21_ni $PINS Y=nx17303 A0=nx35574 A1=camera_module_cache_ram_28__6
+ S0=nx36510
Xix24478 aoi22 $PINS Y=nx24477 A0=camera_module_cache_ram_44__6 A1=nx35890
+ B0=camera_module_cache_ram_60__6 B1=nx35930
Xcamera_module_cache_reg_ram_44__6 dffr $PINS Q=camera_module_cache_ram_44__6
+ QB=#dummy[221] D=nx17293 CLK=clk R=rst
Xix17294 mux21_ni $PINS Y=nx17293 A0=nx35574 A1=camera_module_cache_ram_44__6
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__6 dffr $PINS Q=camera_module_cache_ram_60__6
+ QB=#dummy[222] D=nx17283 CLK=clk R=rst
Xix17284 mux21_ni $PINS Y=nx17283 A0=nx35574 A1=camera_module_cache_ram_60__6
+ S0=nx36518
Xix24491 aoi22 $PINS Y=nx24490 A0=camera_module_cache_ram_76__6 A1=nx35970
+ B0=camera_module_cache_ram_92__6 B1=nx36010
Xcamera_module_cache_reg_ram_76__6 dffr $PINS Q=camera_module_cache_ram_76__6
+ QB=#dummy[223] D=nx17273 CLK=clk R=rst
Xix17274 mux21_ni $PINS Y=nx17273 A0=nx35576 A1=camera_module_cache_ram_76__6
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__6 dffr $PINS Q=camera_module_cache_ram_92__6
+ QB=#dummy[224] D=nx17263 CLK=clk R=rst
Xix17264 mux21_ni $PINS Y=nx17263 A0=nx35576 A1=camera_module_cache_ram_92__6
+ S0=nx36526
Xix24504 aoi22 $PINS Y=nx24503 A0=camera_module_cache_ram_124__6 A1=nx36050
+ B0=camera_module_cache_ram_108__6 B1=nx36090
Xcamera_module_cache_reg_ram_124__6 dffr $PINS Q=camera_module_cache_ram_124__6
+ QB=#dummy[225] D=nx17243 CLK=clk R=rst
Xix17244 mux21_ni $PINS Y=nx17243 A0=nx35576 A1=camera_module_cache_ram_124__6
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__6 dffr $PINS Q=camera_module_cache_ram_108__6
+ QB=#dummy[226] D=nx17253 CLK=clk R=rst
Xix17254 mux21_ni $PINS Y=nx17253 A0=nx35576 A1=camera_module_cache_ram_108__6
+ S0=nx36534
Xix20537 nand04 $PINS Y=nx20536 A0=nx24517 A1=nx24529 A2=nx24544 A3=nx24557
Xix24518 aoi22 $PINS Y=nx24517 A0=camera_module_cache_ram_140__6 A1=nx36130
+ B0=camera_module_cache_ram_156__6 B1=nx36170
Xcamera_module_cache_reg_ram_140__6 dffr $PINS Q=camera_module_cache_ram_140__6
+ QB=#dummy[227] D=nx17233 CLK=clk R=rst
Xix17234 mux21_ni $PINS Y=nx17233 A0=nx35576 A1=camera_module_cache_ram_140__6
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__6 dffr $PINS Q=camera_module_cache_ram_156__6
+ QB=#dummy[228] D=nx17223 CLK=clk R=rst
Xix17224 mux21_ni $PINS Y=nx17223 A0=nx35576 A1=camera_module_cache_ram_156__6
+ S0=nx36542
Xix24530 aoi22 $PINS Y=nx24529 A0=camera_module_cache_ram_188__6 A1=nx36210
+ B0=camera_module_cache_ram_172__6 B1=nx36250
Xcamera_module_cache_reg_ram_188__6 dffr $PINS Q=camera_module_cache_ram_188__6
+ QB=#dummy[229] D=nx17203 CLK=clk R=rst
Xix17204 mux21_ni $PINS Y=nx17203 A0=nx35576 A1=camera_module_cache_ram_188__6
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__6 dffr $PINS Q=camera_module_cache_ram_172__6
+ QB=#dummy[230] D=nx17213 CLK=clk R=rst
Xix17214 mux21_ni $PINS Y=nx17213 A0=nx35578 A1=camera_module_cache_ram_172__6
+ S0=nx36550
Xix24545 aoi22 $PINS Y=nx24544 A0=camera_module_cache_ram_204__6 A1=nx36290
+ B0=camera_module_cache_ram_220__6 B1=nx36330
Xcamera_module_cache_reg_ram_204__6 dffr $PINS Q=camera_module_cache_ram_204__6
+ QB=#dummy[231] D=nx17193 CLK=clk R=rst
Xix17194 mux21_ni $PINS Y=nx17193 A0=nx35578 A1=camera_module_cache_ram_204__6
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__6 dffr $PINS Q=camera_module_cache_ram_220__6
+ QB=#dummy[232] D=nx17183 CLK=clk R=rst
Xix17184 mux21_ni $PINS Y=nx17183 A0=nx35578 A1=camera_module_cache_ram_220__6
+ S0=nx36558
Xix24558 aoi22 $PINS Y=nx24557 A0=camera_module_cache_ram_236__6 A1=nx36370
+ B0=camera_module_cache_ram_252__6 B1=nx36410
Xcamera_module_cache_reg_ram_236__6 dffr $PINS Q=camera_module_cache_ram_236__6
+ QB=#dummy[233] D=nx17173 CLK=clk R=rst
Xix17174 mux21_ni $PINS Y=nx17173 A0=nx35578 A1=camera_module_cache_ram_236__6
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__6 dffr $PINS Q=camera_module_cache_ram_252__6
+ QB=#dummy[234] D=nx17163 CLK=clk R=rst
Xix17164 mux21_ni $PINS Y=nx17163 A0=nx35578 A1=camera_module_cache_ram_252__6
+ S0=nx36566
Xix24573 oai21 $PINS Y=nx24572 A0=nx20452 A1=nx20374 B0=nx36580
Xix20453 nand04 $PINS Y=nx20452 A0=nx24575 A1=nx24592 A2=nx24605 A3=nx24619
Xix24576 aoi22 $PINS Y=nx24575 A0=camera_module_cache_ram_13__6 A1=nx35812
+ B0=camera_module_cache_ram_29__6 B1=nx35852
Xcamera_module_cache_reg_ram_13__6 dffr $PINS Q=camera_module_cache_ram_13__6
+ QB=#dummy[235] D=nx17153 CLK=clk R=rst
Xix17154 mux21_ni $PINS Y=nx17153 A0=nx35578 A1=camera_module_cache_ram_13__6
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__6 dffr $PINS Q=camera_module_cache_ram_29__6
+ QB=#dummy[236] D=nx17143 CLK=clk R=rst
Xix17144 mux21_ni $PINS Y=nx17143 A0=nx35578 A1=camera_module_cache_ram_29__6
+ S0=nx36584
Xix24593 aoi22 $PINS Y=nx24592 A0=camera_module_cache_ram_45__6 A1=nx35892
+ B0=camera_module_cache_ram_61__6 B1=nx35932
Xcamera_module_cache_reg_ram_45__6 dffr $PINS Q=camera_module_cache_ram_45__6
+ QB=#dummy[237] D=nx17133 CLK=clk R=rst
Xix17134 mux21_ni $PINS Y=nx17133 A0=nx35580 A1=camera_module_cache_ram_45__6
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__6 dffr $PINS Q=camera_module_cache_ram_61__6
+ QB=#dummy[238] D=nx17123 CLK=clk R=rst
Xix17124 mux21_ni $PINS Y=nx17123 A0=nx35580 A1=camera_module_cache_ram_61__6
+ S0=nx36592
Xix24606 aoi22 $PINS Y=nx24605 A0=camera_module_cache_ram_77__6 A1=nx35972
+ B0=camera_module_cache_ram_93__6 B1=nx36012
Xcamera_module_cache_reg_ram_77__6 dffr $PINS Q=camera_module_cache_ram_77__6
+ QB=#dummy[239] D=nx17113 CLK=clk R=rst
Xix17114 mux21_ni $PINS Y=nx17113 A0=nx35580 A1=camera_module_cache_ram_77__6
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__6 dffr $PINS Q=camera_module_cache_ram_93__6
+ QB=#dummy[240] D=nx17103 CLK=clk R=rst
Xix17104 mux21_ni $PINS Y=nx17103 A0=nx35580 A1=camera_module_cache_ram_93__6
+ S0=nx36600
Xix24620 aoi22 $PINS Y=nx24619 A0=camera_module_cache_ram_125__6 A1=nx36052
+ B0=camera_module_cache_ram_109__6 B1=nx36092
Xcamera_module_cache_reg_ram_125__6 dffr $PINS Q=camera_module_cache_ram_125__6
+ QB=#dummy[241] D=nx17083 CLK=clk R=rst
Xix17084 mux21_ni $PINS Y=nx17083 A0=nx35580 A1=camera_module_cache_ram_125__6
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__6 dffr $PINS Q=camera_module_cache_ram_109__6
+ QB=#dummy[242] D=nx17093 CLK=clk R=rst
Xix17094 mux21_ni $PINS Y=nx17093 A0=nx35580 A1=camera_module_cache_ram_109__6
+ S0=nx36608
Xix20375 nand04 $PINS Y=nx20374 A0=nx24633 A1=nx24645 A2=nx24659 A3=nx24672
Xix24634 aoi22 $PINS Y=nx24633 A0=camera_module_cache_ram_141__6 A1=nx36132
+ B0=camera_module_cache_ram_157__6 B1=nx36172
Xcamera_module_cache_reg_ram_141__6 dffr $PINS Q=camera_module_cache_ram_141__6
+ QB=#dummy[243] D=nx17073 CLK=clk R=rst
Xix17074 mux21_ni $PINS Y=nx17073 A0=nx35580 A1=camera_module_cache_ram_141__6
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__6 dffr $PINS Q=camera_module_cache_ram_157__6
+ QB=#dummy[244] D=nx17063 CLK=clk R=rst
Xix17064 mux21_ni $PINS Y=nx17063 A0=nx35582 A1=camera_module_cache_ram_157__6
+ S0=nx36616
Xix24646 aoi22 $PINS Y=nx24645 A0=camera_module_cache_ram_189__6 A1=nx36212
+ B0=camera_module_cache_ram_173__6 B1=nx36252
Xcamera_module_cache_reg_ram_189__6 dffr $PINS Q=camera_module_cache_ram_189__6
+ QB=#dummy[245] D=nx17043 CLK=clk R=rst
Xix17044 mux21_ni $PINS Y=nx17043 A0=nx35582 A1=camera_module_cache_ram_189__6
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__6 dffr $PINS Q=camera_module_cache_ram_173__6
+ QB=#dummy[246] D=nx17053 CLK=clk R=rst
Xix17054 mux21_ni $PINS Y=nx17053 A0=nx35582 A1=camera_module_cache_ram_173__6
+ S0=nx36624
Xix24660 aoi22 $PINS Y=nx24659 A0=camera_module_cache_ram_205__6 A1=nx36292
+ B0=camera_module_cache_ram_221__6 B1=nx36332
Xcamera_module_cache_reg_ram_205__6 dffr $PINS Q=camera_module_cache_ram_205__6
+ QB=#dummy[247] D=nx17033 CLK=clk R=rst
Xix17034 mux21_ni $PINS Y=nx17033 A0=nx35582 A1=camera_module_cache_ram_205__6
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__6 dffr $PINS Q=camera_module_cache_ram_221__6
+ QB=#dummy[248] D=nx17023 CLK=clk R=rst
Xix17024 mux21_ni $PINS Y=nx17023 A0=nx35582 A1=camera_module_cache_ram_221__6
+ S0=nx36632
Xix24673 aoi22 $PINS Y=nx24672 A0=camera_module_cache_ram_237__6 A1=nx36372
+ B0=camera_module_cache_ram_253__6 B1=nx36412
Xcamera_module_cache_reg_ram_237__6 dffr $PINS Q=camera_module_cache_ram_237__6
+ QB=#dummy[249] D=nx17013 CLK=clk R=rst
Xix17014 mux21_ni $PINS Y=nx17013 A0=nx35582 A1=camera_module_cache_ram_237__6
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__6 dffr $PINS Q=camera_module_cache_ram_253__6
+ QB=#dummy[250] D=nx17003 CLK=clk R=rst
Xix17004 mux21_ni $PINS Y=nx17003 A0=nx35582 A1=camera_module_cache_ram_253__6
+ S0=nx36640
Xix24687 oai21 $PINS Y=nx24686 A0=nx20288 A1=nx20210 B0=nx36654
Xix20289 nand04 $PINS Y=nx20288 A0=nx24689 A1=nx24707 A2=nx24720 A3=nx24733
Xix24690 aoi22 $PINS Y=nx24689 A0=camera_module_cache_ram_14__6 A1=nx35812
+ B0=camera_module_cache_ram_30__6 B1=nx35852
Xcamera_module_cache_reg_ram_14__6 dffr $PINS Q=camera_module_cache_ram_14__6
+ QB=#dummy[251] D=nx16993 CLK=clk R=rst
Xix16994 mux21_ni $PINS Y=nx16993 A0=nx35584 A1=camera_module_cache_ram_14__6
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__6 dffr $PINS Q=camera_module_cache_ram_30__6
+ QB=#dummy[252] D=nx16983 CLK=clk R=rst
Xix16984 mux21_ni $PINS Y=nx16983 A0=nx35584 A1=camera_module_cache_ram_30__6
+ S0=nx36658
Xix24708 aoi22 $PINS Y=nx24707 A0=camera_module_cache_ram_46__6 A1=nx35892
+ B0=camera_module_cache_ram_62__6 B1=nx35932
Xcamera_module_cache_reg_ram_46__6 dffr $PINS Q=camera_module_cache_ram_46__6
+ QB=#dummy[253] D=nx16973 CLK=clk R=rst
Xix16974 mux21_ni $PINS Y=nx16973 A0=nx35584 A1=camera_module_cache_ram_46__6
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__6 dffr $PINS Q=camera_module_cache_ram_62__6
+ QB=#dummy[254] D=nx16963 CLK=clk R=rst
Xix16964 mux21_ni $PINS Y=nx16963 A0=nx35584 A1=camera_module_cache_ram_62__6
+ S0=nx36666
Xix24721 aoi22 $PINS Y=nx24720 A0=camera_module_cache_ram_78__6 A1=nx35972
+ B0=camera_module_cache_ram_94__6 B1=nx36012
Xcamera_module_cache_reg_ram_78__6 dffr $PINS Q=camera_module_cache_ram_78__6
+ QB=#dummy[255] D=nx16953 CLK=clk R=rst
Xix16954 mux21_ni $PINS Y=nx16953 A0=nx35584 A1=camera_module_cache_ram_78__6
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__6 dffr $PINS Q=camera_module_cache_ram_94__6
+ QB=#dummy[256] D=nx16943 CLK=clk R=rst
Xix16944 mux21_ni $PINS Y=nx16943 A0=nx35584 A1=camera_module_cache_ram_94__6
+ S0=nx36674
Xix24734 aoi22 $PINS Y=nx24733 A0=camera_module_cache_ram_126__6 A1=nx36052
+ B0=camera_module_cache_ram_110__6 B1=nx36092
Xcamera_module_cache_reg_ram_126__6 dffr $PINS Q=camera_module_cache_ram_126__6
+ QB=#dummy[257] D=nx16923 CLK=clk R=rst
Xix16924 mux21_ni $PINS Y=nx16923 A0=nx35584 A1=camera_module_cache_ram_126__6
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__6 dffr $PINS Q=camera_module_cache_ram_110__6
+ QB=#dummy[258] D=nx16933 CLK=clk R=rst
Xix16934 mux21_ni $PINS Y=nx16933 A0=nx35586 A1=camera_module_cache_ram_110__6
+ S0=nx36682
Xix20211 nand04 $PINS Y=nx20210 A0=nx24747 A1=nx24760 A2=nx24774 A3=nx24788
Xix24748 aoi22 $PINS Y=nx24747 A0=camera_module_cache_ram_142__6 A1=nx36132
+ B0=camera_module_cache_ram_158__6 B1=nx36172
Xcamera_module_cache_reg_ram_142__6 dffr $PINS Q=camera_module_cache_ram_142__6
+ QB=#dummy[259] D=nx16913 CLK=clk R=rst
Xix16914 mux21_ni $PINS Y=nx16913 A0=nx35586 A1=camera_module_cache_ram_142__6
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__6 dffr $PINS Q=camera_module_cache_ram_158__6
+ QB=#dummy[260] D=nx16903 CLK=clk R=rst
Xix16904 mux21_ni $PINS Y=nx16903 A0=nx35586 A1=camera_module_cache_ram_158__6
+ S0=nx36690
Xix24761 aoi22 $PINS Y=nx24760 A0=camera_module_cache_ram_190__6 A1=nx36212
+ B0=camera_module_cache_ram_174__6 B1=nx36252
Xcamera_module_cache_reg_ram_190__6 dffr $PINS Q=camera_module_cache_ram_190__6
+ QB=#dummy[261] D=nx16883 CLK=clk R=rst
Xix16884 mux21_ni $PINS Y=nx16883 A0=nx35586 A1=camera_module_cache_ram_190__6
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__6 dffr $PINS Q=camera_module_cache_ram_174__6
+ QB=#dummy[262] D=nx16893 CLK=clk R=rst
Xix16894 mux21_ni $PINS Y=nx16893 A0=nx35586 A1=camera_module_cache_ram_174__6
+ S0=nx36698
Xix24775 aoi22 $PINS Y=nx24774 A0=camera_module_cache_ram_206__6 A1=nx36292
+ B0=camera_module_cache_ram_222__6 B1=nx36332
Xcamera_module_cache_reg_ram_206__6 dffr $PINS Q=camera_module_cache_ram_206__6
+ QB=#dummy[263] D=nx16873 CLK=clk R=rst
Xix16874 mux21_ni $PINS Y=nx16873 A0=nx35586 A1=camera_module_cache_ram_206__6
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__6 dffr $PINS Q=camera_module_cache_ram_222__6
+ QB=#dummy[264] D=nx16863 CLK=clk R=rst
Xix16864 mux21_ni $PINS Y=nx16863 A0=nx35586 A1=camera_module_cache_ram_222__6
+ S0=nx36706
Xix24789 aoi22 $PINS Y=nx24788 A0=camera_module_cache_ram_238__6 A1=nx36372
+ B0=camera_module_cache_ram_254__6 B1=nx36412
Xcamera_module_cache_reg_ram_238__6 dffr $PINS Q=camera_module_cache_ram_238__6
+ QB=#dummy[265] D=nx16853 CLK=clk R=rst
Xix16854 mux21_ni $PINS Y=nx16853 A0=nx35588 A1=camera_module_cache_ram_238__6
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__6 dffr $PINS Q=camera_module_cache_ram_254__6
+ QB=#dummy[266] D=nx16843 CLK=clk R=rst
Xix16844 mux21_ni $PINS Y=nx16843 A0=nx35588 A1=camera_module_cache_ram_254__6
+ S0=nx36714
Xix24802 oai21 $PINS Y=nx24801 A0=nx20126 A1=nx20048 B0=nx36728
Xix20127 nand04 $PINS Y=nx20126 A0=nx24805 A1=nx24819 A2=nx24834 A3=nx24848
Xix24806 aoi22 $PINS Y=nx24805 A0=camera_module_cache_ram_15__6 A1=nx35812
+ B0=camera_module_cache_ram_31__6 B1=nx35852
Xcamera_module_cache_reg_ram_15__6 dffr $PINS Q=camera_module_cache_ram_15__6
+ QB=#dummy[267] D=nx16833 CLK=clk R=rst
Xix16834 mux21_ni $PINS Y=nx16833 A0=nx35588 A1=camera_module_cache_ram_15__6
+ S0=nx36718
Xix24812 nor02_2x $PINS Y=nx24811 A0=nx912 A1=nx842
Xcamera_module_cache_reg_ram_31__6 dffr $PINS Q=camera_module_cache_ram_31__6
+ QB=#dummy[268] D=nx16823 CLK=clk R=rst
Xix16824 mux21_ni $PINS Y=nx16823 A0=nx35588 A1=camera_module_cache_ram_31__6
+ S0=nx36732
Xix24820 aoi22 $PINS Y=nx24819 A0=camera_module_cache_ram_47__6 A1=nx35892
+ B0=camera_module_cache_ram_63__6 B1=nx35932
Xcamera_module_cache_reg_ram_47__6 dffr $PINS Q=camera_module_cache_ram_47__6
+ QB=#dummy[269] D=nx16813 CLK=clk R=rst
Xix16814 mux21_ni $PINS Y=nx16813 A0=nx35588 A1=camera_module_cache_ram_47__6
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__6 dffr $PINS Q=camera_module_cache_ram_63__6
+ QB=#dummy[270] D=nx16803 CLK=clk R=rst
Xix16804 mux21_ni $PINS Y=nx16803 A0=nx35588 A1=camera_module_cache_ram_63__6
+ S0=nx36740
Xix24835 aoi22 $PINS Y=nx24834 A0=camera_module_cache_ram_79__6 A1=nx35972
+ B0=camera_module_cache_ram_95__6 B1=nx36012
Xcamera_module_cache_reg_ram_79__6 dffr $PINS Q=camera_module_cache_ram_79__6
+ QB=#dummy[271] D=nx16793 CLK=clk R=rst
Xix16794 mux21_ni $PINS Y=nx16793 A0=nx35588 A1=camera_module_cache_ram_79__6
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__6 dffr $PINS Q=camera_module_cache_ram_95__6
+ QB=#dummy[272] D=nx16783 CLK=clk R=rst
Xix16784 mux21_ni $PINS Y=nx16783 A0=nx35590 A1=camera_module_cache_ram_95__6
+ S0=nx36748
Xix24849 aoi22 $PINS Y=nx24848 A0=camera_module_cache_ram_127__6 A1=nx36052
+ B0=camera_module_cache_ram_111__6 B1=nx36092
Xcamera_module_cache_reg_ram_127__6 dffr $PINS Q=camera_module_cache_ram_127__6
+ QB=#dummy[273] D=nx16763 CLK=clk R=rst
Xix16764 mux21_ni $PINS Y=nx16763 A0=nx35590 A1=camera_module_cache_ram_127__6
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__6 dffr $PINS Q=camera_module_cache_ram_111__6
+ QB=#dummy[274] D=nx16773 CLK=clk R=rst
Xix16774 mux21_ni $PINS Y=nx16773 A0=nx35590 A1=camera_module_cache_ram_111__6
+ S0=nx36756
Xix20049 nand04 $PINS Y=nx20048 A0=nx24863 A1=nx24877 A2=nx24890 A3=nx24903
Xix24864 aoi22 $PINS Y=nx24863 A0=camera_module_cache_ram_143__6 A1=nx36132
+ B0=camera_module_cache_ram_159__6 B1=nx36172
Xcamera_module_cache_reg_ram_143__6 dffr $PINS Q=camera_module_cache_ram_143__6
+ QB=#dummy[275] D=nx16753 CLK=clk R=rst
Xix16754 mux21_ni $PINS Y=nx16753 A0=nx35590 A1=camera_module_cache_ram_143__6
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__6 dffr $PINS Q=camera_module_cache_ram_159__6
+ QB=#dummy[276] D=nx16743 CLK=clk R=rst
Xix16744 mux21_ni $PINS Y=nx16743 A0=nx35590 A1=camera_module_cache_ram_159__6
+ S0=nx36764
Xix24878 aoi22 $PINS Y=nx24877 A0=camera_module_cache_ram_191__6 A1=nx36212
+ B0=camera_module_cache_ram_175__6 B1=nx36252
Xcamera_module_cache_reg_ram_191__6 dffr $PINS Q=camera_module_cache_ram_191__6
+ QB=#dummy[277] D=nx16723 CLK=clk R=rst
Xix16724 mux21_ni $PINS Y=nx16723 A0=nx35590 A1=camera_module_cache_ram_191__6
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__6 dffr $PINS Q=camera_module_cache_ram_175__6
+ QB=#dummy[278] D=nx16733 CLK=clk R=rst
Xix16734 mux21_ni $PINS Y=nx16733 A0=nx35590 A1=camera_module_cache_ram_175__6
+ S0=nx36772
Xix24891 aoi22 $PINS Y=nx24890 A0=camera_module_cache_ram_207__6 A1=nx36292
+ B0=camera_module_cache_ram_223__6 B1=nx36332
Xcamera_module_cache_reg_ram_207__6 dffr $PINS Q=camera_module_cache_ram_207__6
+ QB=#dummy[279] D=nx16713 CLK=clk R=rst
Xix16714 mux21_ni $PINS Y=nx16713 A0=nx35592 A1=camera_module_cache_ram_207__6
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__6 dffr $PINS Q=camera_module_cache_ram_223__6
+ QB=#dummy[280] D=nx16703 CLK=clk R=rst
Xix16704 mux21_ni $PINS Y=nx16703 A0=nx35592 A1=camera_module_cache_ram_223__6
+ S0=nx36780
Xix24904 aoi22 $PINS Y=nx24903 A0=camera_module_cache_ram_239__6 A1=nx36372
+ B0=camera_module_cache_ram_255__6 B1=nx36412
Xcamera_module_cache_reg_ram_239__6 dffr $PINS Q=camera_module_cache_ram_239__6
+ QB=#dummy[281] D=nx16693 CLK=clk R=rst
Xix16694 mux21_ni $PINS Y=nx16693 A0=nx35592 A1=camera_module_cache_ram_239__6
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__6 dffr $PINS Q=camera_module_cache_ram_255__6
+ QB=#dummy[282] D=nx16683 CLK=clk R=rst
Xix16684 mux21_ni $PINS Y=nx16683 A0=nx35592 A1=camera_module_cache_ram_255__6
+ S0=nx36788
Xix24919 aoi21 $PINS Y=nx24918 A0=nx35806 A1=nx770 B0=nx738
Xix771 nand03 $PINS Y=nx770 A0=nx24921 A1=nx37082 A2=nx24925
Xix24926 aoi21 $PINS Y=nx24925 A0=camera_module_algo_module_address_value_3
+ A1=nx23021 B0=nx752
Xix740 aoi21 $PINS Y=nx738 A0=nx24930 A1=nx24933 B0=nx35806
Xix24931 aoi21 $PINS Y=nx24930 A0=nx37094 A1=nx622 B0=nx37082
Xix623 nor04 $PINS Y=nx622 A0=camera_module_algo_module_address_value_7
+ A1=camera_module_algo_module_address_value_6
+ A2=camera_module_algo_module_address_value_5
+ A3=camera_module_algo_module_address_value_4
Xix24934 mux21_ni $PINS Y=nx24933 A0=nx37094 A1=nx622 S0=nx24935
Xix24936 nand04 $PINS Y=nx24935 A0=camera_module_algo_module_address_value_7
+ A1=camera_module_algo_module_address_value_6
+ A2=camera_module_algo_module_address_value_5
+ A3=camera_module_algo_module_address_value_4
Xix19851 oai22 $PINS Y=nx19850 A0=nx24939 A1=nx31101 B0=nx32240 B1=nx19826
Xix24940 aoi22 $PINS Y=nx24939 A0=camera_module_algo_module_pixel_value_4
+ A1=nx24945 B0=nx14302 B1=nx17068
Xcamera_module_algo_module_pixel_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_pixel_value_4 QB=#dummy[283] D=nx14103 CLK=clk
Xix14104 mux21_ni $PINS Y=nx14103 A0=nx17060
+ A1=camera_module_algo_module_pixel_value_4 S0=nx37152
Xix24946 mux21_ni $PINS Y=nx24945 A0=nx24947 A1=nx35674 S0=nx36792
Xix24948 nor04 $PINS Y=nx24947 A0=nx17040 A1=nx16386 A2=nx15730 A3=nx15076
Xix17041 nand04 $PINS Y=nx17040 A0=nx24951 A1=nx25074 A2=nx25149 A3=nx25227
Xix24952 oai21 $PINS Y=nx24951 A0=nx17030 A1=nx16952 B0=nx36448
Xix17031 nand04 $PINS Y=nx17030 A0=nx24954 A1=nx25009 A2=nx25017 A3=nx25027
Xix24955 aoi22 $PINS Y=nx24954 A0=camera_module_cache_ram_0__4 A1=nx35812
+ B0=camera_module_cache_ram_16__4 B1=nx35852
Xcamera_module_cache_reg_ram_0__4 dffr $PINS Q=camera_module_cache_ram_0__4
+ QB=#dummy[284] D=nx14093 CLK=clk R=rst
Xix14094 mux21_ni $PINS Y=nx14093 A0=camera_module_cache_ram_0__4 A1=nx35368
+ S0=nx35134
Xix14423 oai221 $PINS Y=nx14422 A0=nx34072 A1=nx24960 B0=nx24979 B1=nx35712
+ C0=nx24983
Xnvm_module_tri_dataout_124 tri01 $PINS Y=nvm_data_124 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_116 tri01 $PINS Y=nvm_data_116 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_108 tri01 $PINS Y=nvm_data_108 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_100 tri01 $PINS Y=nvm_data_100 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_92 tri01 $PINS Y=nvm_data_92 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_84 tri01 $PINS Y=nvm_data_84 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_76 tri01 $PINS Y=nvm_data_76 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_68 tri01 $PINS Y=nvm_data_68 A=nx22549
+ E=nvm_module_GND0
Xix24980 inv01 $PINS Y=nx24979 A=nvm_data_4
Xnvm_module_tri_dataout_4 tri01 $PINS Y=nvm_data_4 A=nx22549 E=nvm_module_GND0
Xix24984 nand02 $PINS Y=nx24983 A0=nx34074 A1=nx14356
Xnvm_module_tri_dataout_60 tri01 $PINS Y=nvm_data_60 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_52 tri01 $PINS Y=nvm_data_52 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_44 tri01 $PINS Y=nvm_data_44 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_36 tri01 $PINS Y=nvm_data_36 A=nx22549
+ E=nvm_module_GND0
Xix14325 oai22 $PINS Y=nx14324 A0=nx34100 A1=nx24997 B0=nx34082 B1=nx25001
Xnvm_module_tri_dataout_28 tri01 $PINS Y=nvm_data_28 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_20 tri01 $PINS Y=nvm_data_20 A=nx22549
+ E=nvm_module_GND0
Xix25002 nand02 $PINS Y=nx25001 A0=nvm_data_12 A1=nx34100
Xnvm_module_tri_dataout_12 tri01 $PINS Y=nvm_data_12 A=nx22549
+ E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__4 dffr $PINS Q=camera_module_cache_ram_16__4
+ QB=#dummy[285] D=nx14083 CLK=clk R=rst
Xix14084 mux21_ni $PINS Y=nx14083 A0=camera_module_cache_ram_16__4 A1=nx35368
+ S0=nx35130
Xix25010 aoi22 $PINS Y=nx25009 A0=camera_module_cache_ram_32__4 A1=nx35892
+ B0=camera_module_cache_ram_48__4 B1=nx35932
Xcamera_module_cache_reg_ram_32__4 dffr $PINS Q=camera_module_cache_ram_32__4
+ QB=#dummy[286] D=nx14073 CLK=clk R=rst
Xix14074 mux21_ni $PINS Y=nx14073 A0=camera_module_cache_ram_32__4 A1=nx35368
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__4 dffr $PINS Q=camera_module_cache_ram_48__4
+ QB=#dummy[287] D=nx14063 CLK=clk R=rst
Xix14064 mux21_ni $PINS Y=nx14063 A0=camera_module_cache_ram_48__4 A1=nx35368
+ S0=nx35122
Xix25018 aoi22 $PINS Y=nx25017 A0=camera_module_cache_ram_64__4 A1=nx35972
+ B0=camera_module_cache_ram_80__4 B1=nx36012
Xcamera_module_cache_reg_ram_64__4 dffr $PINS Q=camera_module_cache_ram_64__4
+ QB=#dummy[288] D=nx14053 CLK=clk R=rst
Xix14054 mux21_ni $PINS Y=nx14053 A0=camera_module_cache_ram_64__4 A1=nx35368
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__4 dffr $PINS Q=camera_module_cache_ram_80__4
+ QB=#dummy[289] D=nx14043 CLK=clk R=rst
Xix14044 mux21_ni $PINS Y=nx14043 A0=camera_module_cache_ram_80__4 A1=nx35368
+ S0=nx35114
Xix25028 aoi22 $PINS Y=nx25027 A0=camera_module_cache_ram_112__4 A1=nx36052
+ B0=camera_module_cache_ram_96__4 B1=nx36092
Xcamera_module_cache_reg_ram_112__4 dffr $PINS Q=camera_module_cache_ram_112__4
+ QB=#dummy[290] D=nx14023 CLK=clk R=rst
Xix14024 mux21_ni $PINS Y=nx14023 A0=camera_module_cache_ram_112__4 A1=nx35368
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__4 dffr $PINS Q=camera_module_cache_ram_96__4
+ QB=#dummy[291] D=nx14033 CLK=clk R=rst
Xix14034 mux21_ni $PINS Y=nx14033 A0=camera_module_cache_ram_96__4 A1=nx35370
+ S0=nx35110
Xix16953 nand04 $PINS Y=nx16952 A0=nx25039 A1=nx25047 A2=nx25056 A3=nx25065
Xix25040 aoi22 $PINS Y=nx25039 A0=camera_module_cache_ram_128__4 A1=nx36132
+ B0=camera_module_cache_ram_144__4 B1=nx36172
Xcamera_module_cache_reg_ram_128__4 dffr $PINS Q=camera_module_cache_ram_128__4
+ QB=#dummy[292] D=nx14013 CLK=clk R=rst
Xix14014 mux21_ni $PINS Y=nx14013 A0=camera_module_cache_ram_128__4 A1=nx35370
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__4 dffr $PINS Q=camera_module_cache_ram_144__4
+ QB=#dummy[293] D=nx14003 CLK=clk R=rst
Xix14004 mux21_ni $PINS Y=nx14003 A0=camera_module_cache_ram_144__4 A1=nx35370
+ S0=nx35098
Xix25048 aoi22 $PINS Y=nx25047 A0=camera_module_cache_ram_176__4 A1=nx36212
+ B0=camera_module_cache_ram_160__4 B1=nx36252
Xcamera_module_cache_reg_ram_176__4 dffr $PINS Q=camera_module_cache_ram_176__4
+ QB=#dummy[294] D=nx13983 CLK=clk R=rst
Xix13984 mux21_ni $PINS Y=nx13983 A0=camera_module_cache_ram_176__4 A1=nx35370
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__4 dffr $PINS Q=camera_module_cache_ram_160__4
+ QB=#dummy[295] D=nx13993 CLK=clk R=rst
Xix13994 mux21_ni $PINS Y=nx13993 A0=camera_module_cache_ram_160__4 A1=nx35370
+ S0=nx35094
Xix25057 aoi22 $PINS Y=nx25056 A0=camera_module_cache_ram_192__4 A1=nx36292
+ B0=camera_module_cache_ram_208__4 B1=nx36332
Xcamera_module_cache_reg_ram_192__4 dffr $PINS Q=camera_module_cache_ram_192__4
+ QB=#dummy[296] D=nx13973 CLK=clk R=rst
Xix13974 mux21_ni $PINS Y=nx13973 A0=camera_module_cache_ram_192__4 A1=nx35370
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__4 dffr $PINS Q=camera_module_cache_ram_208__4
+ QB=#dummy[297] D=nx13963 CLK=clk R=rst
Xix13964 mux21_ni $PINS Y=nx13963 A0=camera_module_cache_ram_208__4 A1=nx35370
+ S0=nx35082
Xix25066 aoi22 $PINS Y=nx25065 A0=camera_module_cache_ram_224__4 A1=nx36372
+ B0=camera_module_cache_ram_240__4 B1=nx36412
Xcamera_module_cache_reg_ram_224__4 dffr $PINS Q=camera_module_cache_ram_224__4
+ QB=#dummy[298] D=nx13953 CLK=clk R=rst
Xix13954 mux21_ni $PINS Y=nx13953 A0=camera_module_cache_ram_224__4 A1=nx35372
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__4 dffr $PINS Q=camera_module_cache_ram_240__4
+ QB=#dummy[299] D=nx13943 CLK=clk R=rst
Xix13944 mux21_ni $PINS Y=nx13943 A0=camera_module_cache_ram_240__4 A1=nx35372
+ S0=nx35074
Xix25075 oai21 $PINS Y=nx25074 A0=nx16868 A1=nx16790 B0=nx36452
Xix16869 nand04 $PINS Y=nx16868 A0=nx25077 A1=nx25085 A2=nx25094 A3=nx25103
Xix25078 aoi22 $PINS Y=nx25077 A0=camera_module_cache_ram_1__4 A1=nx35814
+ B0=camera_module_cache_ram_17__4 B1=nx35854
Xcamera_module_cache_reg_ram_1__4 dffr $PINS Q=camera_module_cache_ram_1__4
+ QB=#dummy[300] D=nx13933 CLK=clk R=rst
Xix13934 mux21_ni $PINS Y=nx13933 A0=camera_module_cache_ram_1__4 A1=nx35372
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__4 dffr $PINS Q=camera_module_cache_ram_17__4
+ QB=#dummy[301] D=nx13923 CLK=clk R=rst
Xix13924 mux21_ni $PINS Y=nx13923 A0=camera_module_cache_ram_17__4 A1=nx35372
+ S0=nx35060
Xix25086 aoi22 $PINS Y=nx25085 A0=camera_module_cache_ram_33__4 A1=nx35894
+ B0=camera_module_cache_ram_49__4 B1=nx35934
Xcamera_module_cache_reg_ram_33__4 dffr $PINS Q=camera_module_cache_ram_33__4
+ QB=#dummy[302] D=nx13913 CLK=clk R=rst
Xix13914 mux21_ni $PINS Y=nx13913 A0=camera_module_cache_ram_33__4 A1=nx35372
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__4 dffr $PINS Q=camera_module_cache_ram_49__4
+ QB=#dummy[303] D=nx13903 CLK=clk R=rst
Xix13904 mux21_ni $PINS Y=nx13903 A0=camera_module_cache_ram_49__4 A1=nx35372
+ S0=nx35052
Xix25095 aoi22 $PINS Y=nx25094 A0=camera_module_cache_ram_65__4 A1=nx35974
+ B0=camera_module_cache_ram_81__4 B1=nx36014
Xcamera_module_cache_reg_ram_65__4 dffr $PINS Q=camera_module_cache_ram_65__4
+ QB=#dummy[304] D=nx13893 CLK=clk R=rst
Xix13894 mux21_ni $PINS Y=nx13893 A0=camera_module_cache_ram_65__4 A1=nx35372
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__4 dffr $PINS Q=camera_module_cache_ram_81__4
+ QB=#dummy[305] D=nx13883 CLK=clk R=rst
Xix13884 mux21_ni $PINS Y=nx13883 A0=camera_module_cache_ram_81__4 A1=nx35374
+ S0=nx35044
Xix25104 aoi22 $PINS Y=nx25103 A0=camera_module_cache_ram_113__4 A1=nx36054
+ B0=camera_module_cache_ram_97__4 B1=nx36094
Xcamera_module_cache_reg_ram_113__4 dffr $PINS Q=camera_module_cache_ram_113__4
+ QB=#dummy[306] D=nx13863 CLK=clk R=rst
Xix13864 mux21_ni $PINS Y=nx13863 A0=camera_module_cache_ram_113__4 A1=nx35374
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__4 dffr $PINS Q=camera_module_cache_ram_97__4
+ QB=#dummy[307] D=nx13873 CLK=clk R=rst
Xix13874 mux21_ni $PINS Y=nx13873 A0=camera_module_cache_ram_97__4 A1=nx35374
+ S0=nx35040
Xix16791 nand04 $PINS Y=nx16790 A0=nx25113 A1=nx25122 A2=nx25131 A3=nx25140
Xix25114 aoi22 $PINS Y=nx25113 A0=camera_module_cache_ram_129__4 A1=nx36134
+ B0=camera_module_cache_ram_145__4 B1=nx36174
Xcamera_module_cache_reg_ram_129__4 dffr $PINS Q=camera_module_cache_ram_129__4
+ QB=#dummy[308] D=nx13853 CLK=clk R=rst
Xix13854 mux21_ni $PINS Y=nx13853 A0=camera_module_cache_ram_129__4 A1=nx35374
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__4 dffr $PINS Q=camera_module_cache_ram_145__4
+ QB=#dummy[309] D=nx13843 CLK=clk R=rst
Xix13844 mux21_ni $PINS Y=nx13843 A0=camera_module_cache_ram_145__4 A1=nx35374
+ S0=nx35028
Xix25123 aoi22 $PINS Y=nx25122 A0=camera_module_cache_ram_177__4 A1=nx36214
+ B0=camera_module_cache_ram_161__4 B1=nx36254
Xcamera_module_cache_reg_ram_177__4 dffr $PINS Q=camera_module_cache_ram_177__4
+ QB=#dummy[310] D=nx13823 CLK=clk R=rst
Xix13824 mux21_ni $PINS Y=nx13823 A0=camera_module_cache_ram_177__4 A1=nx35374
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__4 dffr $PINS Q=camera_module_cache_ram_161__4
+ QB=#dummy[311] D=nx13833 CLK=clk R=rst
Xix13834 mux21_ni $PINS Y=nx13833 A0=camera_module_cache_ram_161__4 A1=nx35374
+ S0=nx35024
Xix25132 aoi22 $PINS Y=nx25131 A0=camera_module_cache_ram_193__4 A1=nx36294
+ B0=camera_module_cache_ram_209__4 B1=nx36334
Xcamera_module_cache_reg_ram_193__4 dffr $PINS Q=camera_module_cache_ram_193__4
+ QB=#dummy[312] D=nx13813 CLK=clk R=rst
Xix13814 mux21_ni $PINS Y=nx13813 A0=camera_module_cache_ram_193__4 A1=nx35376
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__4 dffr $PINS Q=camera_module_cache_ram_209__4
+ QB=#dummy[313] D=nx13803 CLK=clk R=rst
Xix13804 mux21_ni $PINS Y=nx13803 A0=camera_module_cache_ram_209__4 A1=nx35376
+ S0=nx35012
Xix25141 aoi22 $PINS Y=nx25140 A0=camera_module_cache_ram_225__4 A1=nx36374
+ B0=camera_module_cache_ram_241__4 B1=nx36414
Xcamera_module_cache_reg_ram_225__4 dffr $PINS Q=camera_module_cache_ram_225__4
+ QB=#dummy[314] D=nx13793 CLK=clk R=rst
Xix13794 mux21_ni $PINS Y=nx13793 A0=camera_module_cache_ram_225__4 A1=nx35376
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__4 dffr $PINS Q=camera_module_cache_ram_241__4
+ QB=#dummy[315] D=nx13783 CLK=clk R=rst
Xix13784 mux21_ni $PINS Y=nx13783 A0=camera_module_cache_ram_241__4 A1=nx35376
+ S0=nx35004
Xix25150 oai21 $PINS Y=nx25149 A0=nx16704 A1=nx16626 B0=nx36456
Xix16705 nand04 $PINS Y=nx16704 A0=nx25153 A1=nx25162 A2=nx25172 A3=nx25181
Xix25154 aoi22 $PINS Y=nx25153 A0=camera_module_cache_ram_2__4 A1=nx35814
+ B0=camera_module_cache_ram_18__4 B1=nx35854
Xcamera_module_cache_reg_ram_2__4 dffr $PINS Q=camera_module_cache_ram_2__4
+ QB=#dummy[316] D=nx13773 CLK=clk R=rst
Xix13774 mux21_ni $PINS Y=nx13773 A0=camera_module_cache_ram_2__4 A1=nx35376
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__4 dffr $PINS Q=camera_module_cache_ram_18__4
+ QB=#dummy[317] D=nx13763 CLK=clk R=rst
Xix13764 mux21_ni $PINS Y=nx13763 A0=camera_module_cache_ram_18__4 A1=nx35376
+ S0=nx34990
Xix25163 aoi22 $PINS Y=nx25162 A0=camera_module_cache_ram_34__4 A1=nx35894
+ B0=camera_module_cache_ram_50__4 B1=nx35934
Xcamera_module_cache_reg_ram_34__4 dffr $PINS Q=camera_module_cache_ram_34__4
+ QB=#dummy[318] D=nx13753 CLK=clk R=rst
Xix13754 mux21_ni $PINS Y=nx13753 A0=camera_module_cache_ram_34__4 A1=nx35376
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__4 dffr $PINS Q=camera_module_cache_ram_50__4
+ QB=#dummy[319] D=nx13743 CLK=clk R=rst
Xix13744 mux21_ni $PINS Y=nx13743 A0=camera_module_cache_ram_50__4 A1=nx35378
+ S0=nx34982
Xix25173 aoi22 $PINS Y=nx25172 A0=camera_module_cache_ram_66__4 A1=nx35974
+ B0=camera_module_cache_ram_82__4 B1=nx36014
Xcamera_module_cache_reg_ram_66__4 dffr $PINS Q=camera_module_cache_ram_66__4
+ QB=#dummy[320] D=nx13733 CLK=clk R=rst
Xix13734 mux21_ni $PINS Y=nx13733 A0=camera_module_cache_ram_66__4 A1=nx35378
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__4 dffr $PINS Q=camera_module_cache_ram_82__4
+ QB=#dummy[321] D=nx13723 CLK=clk R=rst
Xix13724 mux21_ni $PINS Y=nx13723 A0=camera_module_cache_ram_82__4 A1=nx35378
+ S0=nx34974
Xix25182 aoi22 $PINS Y=nx25181 A0=camera_module_cache_ram_114__4 A1=nx36054
+ B0=camera_module_cache_ram_98__4 B1=nx36094
Xcamera_module_cache_reg_ram_114__4 dffr $PINS Q=camera_module_cache_ram_114__4
+ QB=#dummy[322] D=nx13703 CLK=clk R=rst
Xix13704 mux21_ni $PINS Y=nx13703 A0=camera_module_cache_ram_114__4 A1=nx35378
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__4 dffr $PINS Q=camera_module_cache_ram_98__4
+ QB=#dummy[323] D=nx13713 CLK=clk R=rst
Xix13714 mux21_ni $PINS Y=nx13713 A0=camera_module_cache_ram_98__4 A1=nx35378
+ S0=nx34970
Xix16627 nand04 $PINS Y=nx16626 A0=nx25191 A1=nx25201 A2=nx25209 A3=nx25218
Xix25192 aoi22 $PINS Y=nx25191 A0=camera_module_cache_ram_130__4 A1=nx36134
+ B0=camera_module_cache_ram_146__4 B1=nx36174
Xcamera_module_cache_reg_ram_130__4 dffr $PINS Q=camera_module_cache_ram_130__4
+ QB=#dummy[324] D=nx13693 CLK=clk R=rst
Xix13694 mux21_ni $PINS Y=nx13693 A0=camera_module_cache_ram_130__4 A1=nx35378
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__4 dffr $PINS Q=camera_module_cache_ram_146__4
+ QB=#dummy[325] D=nx13683 CLK=clk R=rst
Xix13684 mux21_ni $PINS Y=nx13683 A0=camera_module_cache_ram_146__4 A1=nx35378
+ S0=nx34958
Xix25202 aoi22 $PINS Y=nx25201 A0=camera_module_cache_ram_178__4 A1=nx36214
+ B0=camera_module_cache_ram_162__4 B1=nx36254
Xcamera_module_cache_reg_ram_178__4 dffr $PINS Q=camera_module_cache_ram_178__4
+ QB=#dummy[326] D=nx13663 CLK=clk R=rst
Xix13664 mux21_ni $PINS Y=nx13663 A0=camera_module_cache_ram_178__4 A1=nx35380
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__4 dffr $PINS Q=camera_module_cache_ram_162__4
+ QB=#dummy[327] D=nx13673 CLK=clk R=rst
Xix13674 mux21_ni $PINS Y=nx13673 A0=camera_module_cache_ram_162__4 A1=nx35380
+ S0=nx34954
Xix25210 aoi22 $PINS Y=nx25209 A0=camera_module_cache_ram_194__4 A1=nx36294
+ B0=camera_module_cache_ram_210__4 B1=nx36334
Xcamera_module_cache_reg_ram_194__4 dffr $PINS Q=camera_module_cache_ram_194__4
+ QB=#dummy[328] D=nx13653 CLK=clk R=rst
Xix13654 mux21_ni $PINS Y=nx13653 A0=camera_module_cache_ram_194__4 A1=nx35380
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__4 dffr $PINS Q=camera_module_cache_ram_210__4
+ QB=#dummy[329] D=nx13643 CLK=clk R=rst
Xix13644 mux21_ni $PINS Y=nx13643 A0=camera_module_cache_ram_210__4 A1=nx35380
+ S0=nx34942
Xix25219 aoi22 $PINS Y=nx25218 A0=camera_module_cache_ram_226__4 A1=nx36374
+ B0=camera_module_cache_ram_242__4 B1=nx36414
Xcamera_module_cache_reg_ram_226__4 dffr $PINS Q=camera_module_cache_ram_226__4
+ QB=#dummy[330] D=nx13633 CLK=clk R=rst
Xix13634 mux21_ni $PINS Y=nx13633 A0=camera_module_cache_ram_226__4 A1=nx35380
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__4 dffr $PINS Q=camera_module_cache_ram_242__4
+ QB=#dummy[331] D=nx13623 CLK=clk R=rst
Xix13624 mux21_ni $PINS Y=nx13623 A0=camera_module_cache_ram_242__4 A1=nx35380
+ S0=nx34934
Xix25228 oai21 $PINS Y=nx25227 A0=nx16542 A1=nx16464 B0=nx36460
Xix16543 nand04 $PINS Y=nx16542 A0=nx25231 A1=nx25241 A2=nx25251 A3=nx25261
Xix25232 aoi22 $PINS Y=nx25231 A0=camera_module_cache_ram_3__4 A1=nx35814
+ B0=camera_module_cache_ram_19__4 B1=nx35854
Xcamera_module_cache_reg_ram_3__4 dffr $PINS Q=camera_module_cache_ram_3__4
+ QB=#dummy[332] D=nx13613 CLK=clk R=rst
Xix13614 mux21_ni $PINS Y=nx13613 A0=camera_module_cache_ram_3__4 A1=nx35380
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__4 dffr $PINS Q=camera_module_cache_ram_19__4
+ QB=#dummy[333] D=nx13603 CLK=clk R=rst
Xix13604 mux21_ni $PINS Y=nx13603 A0=camera_module_cache_ram_19__4 A1=nx35382
+ S0=nx34920
Xix25242 aoi22 $PINS Y=nx25241 A0=camera_module_cache_ram_35__4 A1=nx35894
+ B0=camera_module_cache_ram_51__4 B1=nx35934
Xcamera_module_cache_reg_ram_35__4 dffr $PINS Q=camera_module_cache_ram_35__4
+ QB=#dummy[334] D=nx13593 CLK=clk R=rst
Xix13594 mux21_ni $PINS Y=nx13593 A0=camera_module_cache_ram_35__4 A1=nx35382
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__4 dffr $PINS Q=camera_module_cache_ram_51__4
+ QB=#dummy[335] D=nx13583 CLK=clk R=rst
Xix13584 mux21_ni $PINS Y=nx13583 A0=camera_module_cache_ram_51__4 A1=nx35382
+ S0=nx34912
Xix25252 aoi22 $PINS Y=nx25251 A0=camera_module_cache_ram_67__4 A1=nx35974
+ B0=camera_module_cache_ram_83__4 B1=nx36014
Xcamera_module_cache_reg_ram_67__4 dffr $PINS Q=camera_module_cache_ram_67__4
+ QB=#dummy[336] D=nx13573 CLK=clk R=rst
Xix13574 mux21_ni $PINS Y=nx13573 A0=camera_module_cache_ram_67__4 A1=nx35382
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__4 dffr $PINS Q=camera_module_cache_ram_83__4
+ QB=#dummy[337] D=nx13563 CLK=clk R=rst
Xix13564 mux21_ni $PINS Y=nx13563 A0=camera_module_cache_ram_83__4 A1=nx35382
+ S0=nx34904
Xix25262 aoi22 $PINS Y=nx25261 A0=camera_module_cache_ram_115__4 A1=nx36054
+ B0=camera_module_cache_ram_99__4 B1=nx36094
Xcamera_module_cache_reg_ram_115__4 dffr $PINS Q=camera_module_cache_ram_115__4
+ QB=#dummy[338] D=nx13543 CLK=clk R=rst
Xix13544 mux21_ni $PINS Y=nx13543 A0=camera_module_cache_ram_115__4 A1=nx35382
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__4 dffr $PINS Q=camera_module_cache_ram_99__4
+ QB=#dummy[339] D=nx13553 CLK=clk R=rst
Xix13554 mux21_ni $PINS Y=nx13553 A0=camera_module_cache_ram_99__4 A1=nx35382
+ S0=nx34900
Xix16465 nand04 $PINS Y=nx16464 A0=nx25271 A1=nx25281 A2=nx25291 A3=nx25301
Xix25272 aoi22 $PINS Y=nx25271 A0=camera_module_cache_ram_131__4 A1=nx36134
+ B0=camera_module_cache_ram_147__4 B1=nx36174
Xcamera_module_cache_reg_ram_131__4 dffr $PINS Q=camera_module_cache_ram_131__4
+ QB=#dummy[340] D=nx13533 CLK=clk R=rst
Xix13534 mux21_ni $PINS Y=nx13533 A0=camera_module_cache_ram_131__4 A1=nx35384
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__4 dffr $PINS Q=camera_module_cache_ram_147__4
+ QB=#dummy[341] D=nx13523 CLK=clk R=rst
Xix13524 mux21_ni $PINS Y=nx13523 A0=camera_module_cache_ram_147__4 A1=nx35384
+ S0=nx34888
Xix25282 aoi22 $PINS Y=nx25281 A0=camera_module_cache_ram_179__4 A1=nx36214
+ B0=camera_module_cache_ram_163__4 B1=nx36254
Xcamera_module_cache_reg_ram_179__4 dffr $PINS Q=camera_module_cache_ram_179__4
+ QB=#dummy[342] D=nx13503 CLK=clk R=rst
Xix13504 mux21_ni $PINS Y=nx13503 A0=camera_module_cache_ram_179__4 A1=nx35384
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__4 dffr $PINS Q=camera_module_cache_ram_163__4
+ QB=#dummy[343] D=nx13513 CLK=clk R=rst
Xix13514 mux21_ni $PINS Y=nx13513 A0=camera_module_cache_ram_163__4 A1=nx35384
+ S0=nx34884
Xix25292 aoi22 $PINS Y=nx25291 A0=camera_module_cache_ram_195__4 A1=nx36294
+ B0=camera_module_cache_ram_211__4 B1=nx36334
Xcamera_module_cache_reg_ram_195__4 dffr $PINS Q=camera_module_cache_ram_195__4
+ QB=#dummy[344] D=nx13493 CLK=clk R=rst
Xix13494 mux21_ni $PINS Y=nx13493 A0=camera_module_cache_ram_195__4 A1=nx35384
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__4 dffr $PINS Q=camera_module_cache_ram_211__4
+ QB=#dummy[345] D=nx13483 CLK=clk R=rst
Xix13484 mux21_ni $PINS Y=nx13483 A0=camera_module_cache_ram_211__4 A1=nx35384
+ S0=nx34872
Xix25302 aoi22 $PINS Y=nx25301 A0=camera_module_cache_ram_227__4 A1=nx36374
+ B0=camera_module_cache_ram_243__4 B1=nx36414
Xcamera_module_cache_reg_ram_227__4 dffr $PINS Q=camera_module_cache_ram_227__4
+ QB=#dummy[346] D=nx13473 CLK=clk R=rst
Xix13474 mux21_ni $PINS Y=nx13473 A0=camera_module_cache_ram_227__4 A1=nx35384
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__4 dffr $PINS Q=camera_module_cache_ram_243__4
+ QB=#dummy[347] D=nx13463 CLK=clk R=rst
Xix13464 mux21_ni $PINS Y=nx13463 A0=camera_module_cache_ram_243__4 A1=nx35386
+ S0=nx34864
Xix16387 nand04 $PINS Y=nx16386 A0=nx25311 A1=nx25397 A2=nx25489 A3=nx25576
Xix25312 oai21 $PINS Y=nx25311 A0=nx16376 A1=nx16298 B0=nx36464
Xix16377 nand04 $PINS Y=nx16376 A0=nx25315 A1=nx25324 A2=nx25334 A3=nx25343
Xix25316 aoi22 $PINS Y=nx25315 A0=camera_module_cache_ram_4__4 A1=nx35814
+ B0=camera_module_cache_ram_20__4 B1=nx35854
Xcamera_module_cache_reg_ram_4__4 dffr $PINS Q=camera_module_cache_ram_4__4
+ QB=#dummy[348] D=nx13453 CLK=clk R=rst
Xix13454 mux21_ni $PINS Y=nx13453 A0=camera_module_cache_ram_4__4 A1=nx35386
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__4 dffr $PINS Q=camera_module_cache_ram_20__4
+ QB=#dummy[349] D=nx13443 CLK=clk R=rst
Xix13444 mux21_ni $PINS Y=nx13443 A0=camera_module_cache_ram_20__4 A1=nx35386
+ S0=nx34850
Xix25325 aoi22 $PINS Y=nx25324 A0=camera_module_cache_ram_36__4 A1=nx35894
+ B0=camera_module_cache_ram_52__4 B1=nx35934
Xcamera_module_cache_reg_ram_36__4 dffr $PINS Q=camera_module_cache_ram_36__4
+ QB=#dummy[350] D=nx13433 CLK=clk R=rst
Xix13434 mux21_ni $PINS Y=nx13433 A0=camera_module_cache_ram_36__4 A1=nx35386
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__4 dffr $PINS Q=camera_module_cache_ram_52__4
+ QB=#dummy[351] D=nx13423 CLK=clk R=rst
Xix13424 mux21_ni $PINS Y=nx13423 A0=camera_module_cache_ram_52__4 A1=nx35386
+ S0=nx34842
Xix25335 aoi22 $PINS Y=nx25334 A0=camera_module_cache_ram_68__4 A1=nx35974
+ B0=camera_module_cache_ram_84__4 B1=nx36014
Xcamera_module_cache_reg_ram_68__4 dffr $PINS Q=camera_module_cache_ram_68__4
+ QB=#dummy[352] D=nx13413 CLK=clk R=rst
Xix13414 mux21_ni $PINS Y=nx13413 A0=camera_module_cache_ram_68__4 A1=nx35386
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__4 dffr $PINS Q=camera_module_cache_ram_84__4
+ QB=#dummy[353] D=nx13403 CLK=clk R=rst
Xix13404 mux21_ni $PINS Y=nx13403 A0=camera_module_cache_ram_84__4 A1=nx35386
+ S0=nx34834
Xix25344 aoi22 $PINS Y=nx25343 A0=camera_module_cache_ram_116__4 A1=nx36054
+ B0=camera_module_cache_ram_100__4 B1=nx36094
Xcamera_module_cache_reg_ram_116__4 dffr $PINS Q=camera_module_cache_ram_116__4
+ QB=#dummy[354] D=nx13383 CLK=clk R=rst
Xix13384 mux21_ni $PINS Y=nx13383 A0=camera_module_cache_ram_116__4 A1=nx35388
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__4 dffr $PINS Q=camera_module_cache_ram_100__4
+ QB=#dummy[355] D=nx13393 CLK=clk R=rst
Xix13394 mux21_ni $PINS Y=nx13393 A0=camera_module_cache_ram_100__4 A1=nx35388
+ S0=nx34830
Xix16299 nand04 $PINS Y=nx16298 A0=nx25353 A1=nx25365 A2=nx25376 A3=nx25386
Xix25354 aoi22 $PINS Y=nx25353 A0=camera_module_cache_ram_132__4 A1=nx36134
+ B0=camera_module_cache_ram_148__4 B1=nx36174
Xcamera_module_cache_reg_ram_132__4 dffr $PINS Q=camera_module_cache_ram_132__4
+ QB=#dummy[356] D=nx13373 CLK=clk R=rst
Xix13374 mux21_ni $PINS Y=nx13373 A0=camera_module_cache_ram_132__4 A1=nx35388
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__4 dffr $PINS Q=camera_module_cache_ram_148__4
+ QB=#dummy[357] D=nx13363 CLK=clk R=rst
Xix13364 mux21_ni $PINS Y=nx13363 A0=camera_module_cache_ram_148__4 A1=nx35388
+ S0=nx34818
Xix25366 aoi22 $PINS Y=nx25365 A0=camera_module_cache_ram_180__4 A1=nx36214
+ B0=camera_module_cache_ram_164__4 B1=nx36254
Xcamera_module_cache_reg_ram_180__4 dffr $PINS Q=camera_module_cache_ram_180__4
+ QB=#dummy[358] D=nx13343 CLK=clk R=rst
Xix13344 mux21_ni $PINS Y=nx13343 A0=camera_module_cache_ram_180__4 A1=nx35388
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__4 dffr $PINS Q=camera_module_cache_ram_164__4
+ QB=#dummy[359] D=nx13353 CLK=clk R=rst
Xix13354 mux21_ni $PINS Y=nx13353 A0=camera_module_cache_ram_164__4 A1=nx35388
+ S0=nx34814
Xix25377 aoi22 $PINS Y=nx25376 A0=camera_module_cache_ram_196__4 A1=nx36294
+ B0=camera_module_cache_ram_212__4 B1=nx36334
Xcamera_module_cache_reg_ram_196__4 dffr $PINS Q=camera_module_cache_ram_196__4
+ QB=#dummy[360] D=nx13333 CLK=clk R=rst
Xix13334 mux21_ni $PINS Y=nx13333 A0=camera_module_cache_ram_196__4 A1=nx35388
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__4 dffr $PINS Q=camera_module_cache_ram_212__4
+ QB=#dummy[361] D=nx13323 CLK=clk R=rst
Xix13324 mux21_ni $PINS Y=nx13323 A0=camera_module_cache_ram_212__4 A1=nx35390
+ S0=nx34802
Xix25387 aoi22 $PINS Y=nx25386 A0=camera_module_cache_ram_228__4 A1=nx36374
+ B0=camera_module_cache_ram_244__4 B1=nx36414
Xcamera_module_cache_reg_ram_228__4 dffr $PINS Q=camera_module_cache_ram_228__4
+ QB=#dummy[362] D=nx13313 CLK=clk R=rst
Xix13314 mux21_ni $PINS Y=nx13313 A0=camera_module_cache_ram_228__4 A1=nx35390
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__4 dffr $PINS Q=camera_module_cache_ram_244__4
+ QB=#dummy[363] D=nx13303 CLK=clk R=rst
Xix13304 mux21_ni $PINS Y=nx13303 A0=camera_module_cache_ram_244__4 A1=nx35390
+ S0=nx34794
Xix25398 oai21 $PINS Y=nx25397 A0=nx16214 A1=nx16136 B0=nx36468
Xix16215 nand04 $PINS Y=nx16214 A0=nx25401 A1=nx25413 A2=nx25425 A3=nx25437
Xix25402 aoi22 $PINS Y=nx25401 A0=camera_module_cache_ram_5__4 A1=nx35814
+ B0=camera_module_cache_ram_21__4 B1=nx35854
Xcamera_module_cache_reg_ram_5__4 dffr $PINS Q=camera_module_cache_ram_5__4
+ QB=#dummy[364] D=nx13293 CLK=clk R=rst
Xix13294 mux21_ni $PINS Y=nx13293 A0=camera_module_cache_ram_5__4 A1=nx35390
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__4 dffr $PINS Q=camera_module_cache_ram_21__4
+ QB=#dummy[365] D=nx13283 CLK=clk R=rst
Xix13284 mux21_ni $PINS Y=nx13283 A0=camera_module_cache_ram_21__4 A1=nx35390
+ S0=nx34780
Xix25414 aoi22 $PINS Y=nx25413 A0=camera_module_cache_ram_37__4 A1=nx35894
+ B0=camera_module_cache_ram_53__4 B1=nx35934
Xcamera_module_cache_reg_ram_37__4 dffr $PINS Q=camera_module_cache_ram_37__4
+ QB=#dummy[366] D=nx13273 CLK=clk R=rst
Xix13274 mux21_ni $PINS Y=nx13273 A0=camera_module_cache_ram_37__4 A1=nx35390
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__4 dffr $PINS Q=camera_module_cache_ram_53__4
+ QB=#dummy[367] D=nx13263 CLK=clk R=rst
Xix13264 mux21_ni $PINS Y=nx13263 A0=camera_module_cache_ram_53__4 A1=nx35390
+ S0=nx34772
Xix25426 aoi22 $PINS Y=nx25425 A0=camera_module_cache_ram_69__4 A1=nx35974
+ B0=camera_module_cache_ram_85__4 B1=nx36014
Xcamera_module_cache_reg_ram_69__4 dffr $PINS Q=camera_module_cache_ram_69__4
+ QB=#dummy[368] D=nx13253 CLK=clk R=rst
Xix13254 mux21_ni $PINS Y=nx13253 A0=camera_module_cache_ram_69__4 A1=nx35392
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__4 dffr $PINS Q=camera_module_cache_ram_85__4
+ QB=#dummy[369] D=nx13243 CLK=clk R=rst
Xix13244 mux21_ni $PINS Y=nx13243 A0=camera_module_cache_ram_85__4 A1=nx35392
+ S0=nx34764
Xix25438 aoi22 $PINS Y=nx25437 A0=camera_module_cache_ram_117__4 A1=nx36054
+ B0=camera_module_cache_ram_101__4 B1=nx36094
Xcamera_module_cache_reg_ram_117__4 dffr $PINS Q=camera_module_cache_ram_117__4
+ QB=#dummy[370] D=nx13223 CLK=clk R=rst
Xix13224 mux21_ni $PINS Y=nx13223 A0=camera_module_cache_ram_117__4 A1=nx35392
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__4 dffr $PINS Q=camera_module_cache_ram_101__4
+ QB=#dummy[371] D=nx13233 CLK=clk R=rst
Xix13234 mux21_ni $PINS Y=nx13233 A0=camera_module_cache_ram_101__4 A1=nx35392
+ S0=nx34760
Xix16137 nand04 $PINS Y=nx16136 A0=nx25449 A1=nx25459 A2=nx25469 A3=nx25480
Xix25450 aoi22 $PINS Y=nx25449 A0=camera_module_cache_ram_133__4 A1=nx36134
+ B0=camera_module_cache_ram_149__4 B1=nx36174
Xcamera_module_cache_reg_ram_133__4 dffr $PINS Q=camera_module_cache_ram_133__4
+ QB=#dummy[372] D=nx13213 CLK=clk R=rst
Xix13214 mux21_ni $PINS Y=nx13213 A0=camera_module_cache_ram_133__4 A1=nx35392
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__4 dffr $PINS Q=camera_module_cache_ram_149__4
+ QB=#dummy[373] D=nx13203 CLK=clk R=rst
Xix13204 mux21_ni $PINS Y=nx13203 A0=camera_module_cache_ram_149__4 A1=nx35392
+ S0=nx34748
Xix25460 aoi22 $PINS Y=nx25459 A0=camera_module_cache_ram_181__4 A1=nx36214
+ B0=camera_module_cache_ram_165__4 B1=nx36254
Xcamera_module_cache_reg_ram_181__4 dffr $PINS Q=camera_module_cache_ram_181__4
+ QB=#dummy[374] D=nx13183 CLK=clk R=rst
Xix13184 mux21_ni $PINS Y=nx13183 A0=camera_module_cache_ram_181__4 A1=nx35392
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__4 dffr $PINS Q=camera_module_cache_ram_165__4
+ QB=#dummy[375] D=nx13193 CLK=clk R=rst
Xix13194 mux21_ni $PINS Y=nx13193 A0=camera_module_cache_ram_165__4 A1=nx35394
+ S0=nx34744
Xix25470 aoi22 $PINS Y=nx25469 A0=camera_module_cache_ram_197__4 A1=nx36294
+ B0=camera_module_cache_ram_213__4 B1=nx36334
Xcamera_module_cache_reg_ram_197__4 dffr $PINS Q=camera_module_cache_ram_197__4
+ QB=#dummy[376] D=nx13173 CLK=clk R=rst
Xix13174 mux21_ni $PINS Y=nx13173 A0=camera_module_cache_ram_197__4 A1=nx35394
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__4 dffr $PINS Q=camera_module_cache_ram_213__4
+ QB=#dummy[377] D=nx13163 CLK=clk R=rst
Xix13164 mux21_ni $PINS Y=nx13163 A0=camera_module_cache_ram_213__4 A1=nx35394
+ S0=nx34732
Xix25481 aoi22 $PINS Y=nx25480 A0=camera_module_cache_ram_229__4 A1=nx36374
+ B0=camera_module_cache_ram_245__4 B1=nx36414
Xcamera_module_cache_reg_ram_229__4 dffr $PINS Q=camera_module_cache_ram_229__4
+ QB=#dummy[378] D=nx13153 CLK=clk R=rst
Xix13154 mux21_ni $PINS Y=nx13153 A0=camera_module_cache_ram_229__4 A1=nx35394
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__4 dffr $PINS Q=camera_module_cache_ram_245__4
+ QB=#dummy[379] D=nx13143 CLK=clk R=rst
Xix13144 mux21_ni $PINS Y=nx13143 A0=camera_module_cache_ram_245__4 A1=nx35394
+ S0=nx34724
Xix25490 oai21 $PINS Y=nx25489 A0=nx16050 A1=nx15972 B0=nx36472
Xix16051 nand04 $PINS Y=nx16050 A0=nx25493 A1=nx25502 A2=nx25515 A3=nx25525
Xix25494 aoi22 $PINS Y=nx25493 A0=camera_module_cache_ram_6__4 A1=nx35814
+ B0=camera_module_cache_ram_22__4 B1=nx35854
Xcamera_module_cache_reg_ram_6__4 dffr $PINS Q=camera_module_cache_ram_6__4
+ QB=#dummy[380] D=nx13133 CLK=clk R=rst
Xix13134 mux21_ni $PINS Y=nx13133 A0=camera_module_cache_ram_6__4 A1=nx35394
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__4 dffr $PINS Q=camera_module_cache_ram_22__4
+ QB=#dummy[381] D=nx13123 CLK=clk R=rst
Xix13124 mux21_ni $PINS Y=nx13123 A0=camera_module_cache_ram_22__4 A1=nx35394
+ S0=nx34710
Xix25504 aoi22 $PINS Y=nx25502 A0=camera_module_cache_ram_38__4 A1=nx35894
+ B0=camera_module_cache_ram_54__4 B1=nx35934
Xcamera_module_cache_reg_ram_38__4 dffr $PINS Q=camera_module_cache_ram_38__4
+ QB=#dummy[382] D=nx13113 CLK=clk R=rst
Xix13114 mux21_ni $PINS Y=nx13113 A0=camera_module_cache_ram_38__4 A1=nx35396
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__4 dffr $PINS Q=camera_module_cache_ram_54__4
+ QB=#dummy[383] D=nx13103 CLK=clk R=rst
Xix13104 mux21_ni $PINS Y=nx13103 A0=camera_module_cache_ram_54__4 A1=nx35396
+ S0=nx34702
Xix25516 aoi22 $PINS Y=nx25515 A0=camera_module_cache_ram_70__4 A1=nx35974
+ B0=camera_module_cache_ram_86__4 B1=nx36014
Xcamera_module_cache_reg_ram_70__4 dffr $PINS Q=camera_module_cache_ram_70__4
+ QB=#dummy[384] D=nx13093 CLK=clk R=rst
Xix13094 mux21_ni $PINS Y=nx13093 A0=camera_module_cache_ram_70__4 A1=nx35396
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__4 dffr $PINS Q=camera_module_cache_ram_86__4
+ QB=#dummy[385] D=nx13083 CLK=clk R=rst
Xix13084 mux21_ni $PINS Y=nx13083 A0=camera_module_cache_ram_86__4 A1=nx35396
+ S0=nx34694
Xix25526 aoi22 $PINS Y=nx25525 A0=camera_module_cache_ram_118__4 A1=nx36054
+ B0=camera_module_cache_ram_102__4 B1=nx36094
Xcamera_module_cache_reg_ram_118__4 dffr $PINS Q=camera_module_cache_ram_118__4
+ QB=#dummy[386] D=nx13063 CLK=clk R=rst
Xix13064 mux21_ni $PINS Y=nx13063 A0=camera_module_cache_ram_118__4 A1=nx35396
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__4 dffr $PINS Q=camera_module_cache_ram_102__4
+ QB=#dummy[387] D=nx13073 CLK=clk R=rst
Xix13074 mux21_ni $PINS Y=nx13073 A0=camera_module_cache_ram_102__4 A1=nx35396
+ S0=nx34690
Xix15973 nand04 $PINS Y=nx15972 A0=nx25536 A1=nx25549 A2=nx25559 A3=nx25568
Xix25538 aoi22 $PINS Y=nx25536 A0=camera_module_cache_ram_134__4 A1=nx36134
+ B0=camera_module_cache_ram_150__4 B1=nx36174
Xcamera_module_cache_reg_ram_134__4 dffr $PINS Q=camera_module_cache_ram_134__4
+ QB=#dummy[388] D=nx13053 CLK=clk R=rst
Xix13054 mux21_ni $PINS Y=nx13053 A0=camera_module_cache_ram_134__4 A1=nx35396
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__4 dffr $PINS Q=camera_module_cache_ram_150__4
+ QB=#dummy[389] D=nx13043 CLK=clk R=rst
Xix13044 mux21_ni $PINS Y=nx13043 A0=camera_module_cache_ram_150__4 A1=nx35398
+ S0=nx34678
Xix25550 aoi22 $PINS Y=nx25549 A0=camera_module_cache_ram_182__4 A1=nx36214
+ B0=camera_module_cache_ram_166__4 B1=nx36254
Xcamera_module_cache_reg_ram_182__4 dffr $PINS Q=camera_module_cache_ram_182__4
+ QB=#dummy[390] D=nx13023 CLK=clk R=rst
Xix13024 mux21_ni $PINS Y=nx13023 A0=camera_module_cache_ram_182__4 A1=nx35398
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__4 dffr $PINS Q=camera_module_cache_ram_166__4
+ QB=#dummy[391] D=nx13033 CLK=clk R=rst
Xix13034 mux21_ni $PINS Y=nx13033 A0=camera_module_cache_ram_166__4 A1=nx35398
+ S0=nx34674
Xix25560 aoi22 $PINS Y=nx25559 A0=camera_module_cache_ram_198__4 A1=nx36294
+ B0=camera_module_cache_ram_214__4 B1=nx36334
Xcamera_module_cache_reg_ram_198__4 dffr $PINS Q=camera_module_cache_ram_198__4
+ QB=#dummy[392] D=nx13013 CLK=clk R=rst
Xix13014 mux21_ni $PINS Y=nx13013 A0=camera_module_cache_ram_198__4 A1=nx35398
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__4 dffr $PINS Q=camera_module_cache_ram_214__4
+ QB=#dummy[393] D=nx13003 CLK=clk R=rst
Xix13004 mux21_ni $PINS Y=nx13003 A0=camera_module_cache_ram_214__4 A1=nx35398
+ S0=nx34662
Xix25569 aoi22 $PINS Y=nx25568 A0=camera_module_cache_ram_230__4 A1=nx36374
+ B0=camera_module_cache_ram_246__4 B1=nx36414
Xcamera_module_cache_reg_ram_230__4 dffr $PINS Q=camera_module_cache_ram_230__4
+ QB=#dummy[394] D=nx12993 CLK=clk R=rst
Xix12994 mux21_ni $PINS Y=nx12993 A0=camera_module_cache_ram_230__4 A1=nx35398
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__4 dffr $PINS Q=camera_module_cache_ram_246__4
+ QB=#dummy[395] D=nx12983 CLK=clk R=rst
Xix12984 mux21_ni $PINS Y=nx12983 A0=camera_module_cache_ram_246__4 A1=nx35398
+ S0=nx34654
Xix25578 oai21 $PINS Y=nx25576 A0=nx15888 A1=nx15810 B0=nx36476
Xix15889 nand04 $PINS Y=nx15888 A0=nx25581 A1=nx25593 A2=nx25604 A3=nx25613
Xix25582 aoi22 $PINS Y=nx25581 A0=camera_module_cache_ram_7__4 A1=nx35814
+ B0=camera_module_cache_ram_23__4 B1=nx35854
Xcamera_module_cache_reg_ram_7__4 dffr $PINS Q=camera_module_cache_ram_7__4
+ QB=#dummy[396] D=nx12973 CLK=clk R=rst
Xix12974 mux21_ni $PINS Y=nx12973 A0=camera_module_cache_ram_7__4 A1=nx35400
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__4 dffr $PINS Q=camera_module_cache_ram_23__4
+ QB=#dummy[397] D=nx12963 CLK=clk R=rst
Xix12964 mux21_ni $PINS Y=nx12963 A0=camera_module_cache_ram_23__4 A1=nx35400
+ S0=nx34640
Xix25594 aoi22 $PINS Y=nx25593 A0=camera_module_cache_ram_39__4 A1=nx35894
+ B0=camera_module_cache_ram_55__4 B1=nx35934
Xcamera_module_cache_reg_ram_39__4 dffr $PINS Q=camera_module_cache_ram_39__4
+ QB=#dummy[398] D=nx12953 CLK=clk R=rst
Xix12954 mux21_ni $PINS Y=nx12953 A0=camera_module_cache_ram_39__4 A1=nx35400
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__4 dffr $PINS Q=camera_module_cache_ram_55__4
+ QB=#dummy[399] D=nx12943 CLK=clk R=rst
Xix12944 mux21_ni $PINS Y=nx12943 A0=camera_module_cache_ram_55__4 A1=nx35400
+ S0=nx34632
Xix25605 aoi22 $PINS Y=nx25604 A0=camera_module_cache_ram_71__4 A1=nx35974
+ B0=camera_module_cache_ram_87__4 B1=nx36014
Xcamera_module_cache_reg_ram_71__4 dffr $PINS Q=camera_module_cache_ram_71__4
+ QB=#dummy[400] D=nx12933 CLK=clk R=rst
Xix12934 mux21_ni $PINS Y=nx12933 A0=camera_module_cache_ram_71__4 A1=nx35400
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__4 dffr $PINS Q=camera_module_cache_ram_87__4
+ QB=#dummy[401] D=nx12923 CLK=clk R=rst
Xix12924 mux21_ni $PINS Y=nx12923 A0=camera_module_cache_ram_87__4 A1=nx35400
+ S0=nx34624
Xix25614 aoi22 $PINS Y=nx25613 A0=camera_module_cache_ram_119__4 A1=nx36054
+ B0=camera_module_cache_ram_103__4 B1=nx36094
Xcamera_module_cache_reg_ram_119__4 dffr $PINS Q=camera_module_cache_ram_119__4
+ QB=#dummy[402] D=nx12903 CLK=clk R=rst
Xix12904 mux21_ni $PINS Y=nx12903 A0=camera_module_cache_ram_119__4 A1=nx35400
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__4 dffr $PINS Q=camera_module_cache_ram_103__4
+ QB=#dummy[403] D=nx12913 CLK=clk R=rst
Xix12914 mux21_ni $PINS Y=nx12913 A0=camera_module_cache_ram_103__4 A1=nx35402
+ S0=nx34620
Xix15811 nand04 $PINS Y=nx15810 A0=nx25625 A1=nx25634 A2=nx25644 A3=nx25655
Xix25626 aoi22 $PINS Y=nx25625 A0=camera_module_cache_ram_135__4 A1=nx36134
+ B0=camera_module_cache_ram_151__4 B1=nx36174
Xcamera_module_cache_reg_ram_135__4 dffr $PINS Q=camera_module_cache_ram_135__4
+ QB=#dummy[404] D=nx12893 CLK=clk R=rst
Xix12894 mux21_ni $PINS Y=nx12893 A0=camera_module_cache_ram_135__4 A1=nx35402
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__4 dffr $PINS Q=camera_module_cache_ram_151__4
+ QB=#dummy[405] D=nx12883 CLK=clk R=rst
Xix12884 mux21_ni $PINS Y=nx12883 A0=camera_module_cache_ram_151__4 A1=nx35402
+ S0=nx34608
Xix25635 aoi22 $PINS Y=nx25634 A0=camera_module_cache_ram_183__4 A1=nx36214
+ B0=camera_module_cache_ram_167__4 B1=nx36254
Xcamera_module_cache_reg_ram_183__4 dffr $PINS Q=camera_module_cache_ram_183__4
+ QB=#dummy[406] D=nx12863 CLK=clk R=rst
Xix12864 mux21_ni $PINS Y=nx12863 A0=camera_module_cache_ram_183__4 A1=nx35402
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__4 dffr $PINS Q=camera_module_cache_ram_167__4
+ QB=#dummy[407] D=nx12873 CLK=clk R=rst
Xix12874 mux21_ni $PINS Y=nx12873 A0=camera_module_cache_ram_167__4 A1=nx35402
+ S0=nx34604
Xix25645 aoi22 $PINS Y=nx25644 A0=camera_module_cache_ram_199__4 A1=nx36294
+ B0=camera_module_cache_ram_215__4 B1=nx36334
Xcamera_module_cache_reg_ram_199__4 dffr $PINS Q=camera_module_cache_ram_199__4
+ QB=#dummy[408] D=nx12853 CLK=clk R=rst
Xix12854 mux21_ni $PINS Y=nx12853 A0=camera_module_cache_ram_199__4 A1=nx35402
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__4 dffr $PINS Q=camera_module_cache_ram_215__4
+ QB=#dummy[409] D=nx12843 CLK=clk R=rst
Xix12844 mux21_ni $PINS Y=nx12843 A0=camera_module_cache_ram_215__4 A1=nx35402
+ S0=nx34592
Xix25656 aoi22 $PINS Y=nx25655 A0=camera_module_cache_ram_231__4 A1=nx36374
+ B0=camera_module_cache_ram_247__4 B1=nx36414
Xcamera_module_cache_reg_ram_231__4 dffr $PINS Q=camera_module_cache_ram_231__4
+ QB=#dummy[410] D=nx12833 CLK=clk R=rst
Xix12834 mux21_ni $PINS Y=nx12833 A0=camera_module_cache_ram_231__4 A1=nx35404
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__4 dffr $PINS Q=camera_module_cache_ram_247__4
+ QB=#dummy[411] D=nx12823 CLK=clk R=rst
Xix12824 mux21_ni $PINS Y=nx12823 A0=camera_module_cache_ram_247__4 A1=nx35404
+ S0=nx34584
Xix15731 nand04 $PINS Y=nx15730 A0=nx25667 A1=nx25754 A2=nx25842 A3=nx25926
Xix25668 oai21 $PINS Y=nx25667 A0=nx15720 A1=nx15642 B0=nx36480
Xix15721 nand04 $PINS Y=nx15720 A0=nx25671 A1=nx25681 A2=nx25691 A3=nx25702
Xix25672 aoi22 $PINS Y=nx25671 A0=camera_module_cache_ram_8__4 A1=nx35816
+ B0=camera_module_cache_ram_24__4 B1=nx35856
Xcamera_module_cache_reg_ram_8__4 dffr $PINS Q=camera_module_cache_ram_8__4
+ QB=#dummy[412] D=nx12813 CLK=clk R=rst
Xix12814 mux21_ni $PINS Y=nx12813 A0=camera_module_cache_ram_8__4 A1=nx35404
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__4 dffr $PINS Q=camera_module_cache_ram_24__4
+ QB=#dummy[413] D=nx12803 CLK=clk R=rst
Xix12804 mux21_ni $PINS Y=nx12803 A0=camera_module_cache_ram_24__4 A1=nx35404
+ S0=nx34570
Xix25682 aoi22 $PINS Y=nx25681 A0=camera_module_cache_ram_40__4 A1=nx35896
+ B0=camera_module_cache_ram_56__4 B1=nx35936
Xcamera_module_cache_reg_ram_40__4 dffr $PINS Q=camera_module_cache_ram_40__4
+ QB=#dummy[414] D=nx12793 CLK=clk R=rst
Xix12794 mux21_ni $PINS Y=nx12793 A0=camera_module_cache_ram_40__4 A1=nx35404
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__4 dffr $PINS Q=camera_module_cache_ram_56__4
+ QB=#dummy[415] D=nx12783 CLK=clk R=rst
Xix12784 mux21_ni $PINS Y=nx12783 A0=camera_module_cache_ram_56__4 A1=nx35404
+ S0=nx34562
Xix25692 aoi22 $PINS Y=nx25691 A0=camera_module_cache_ram_72__4 A1=nx35976
+ B0=camera_module_cache_ram_88__4 B1=nx36016
Xcamera_module_cache_reg_ram_72__4 dffr $PINS Q=camera_module_cache_ram_72__4
+ QB=#dummy[416] D=nx12773 CLK=clk R=rst
Xix12774 mux21_ni $PINS Y=nx12773 A0=camera_module_cache_ram_72__4 A1=nx35404
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__4 dffr $PINS Q=camera_module_cache_ram_88__4
+ QB=#dummy[417] D=nx12763 CLK=clk R=rst
Xix12764 mux21_ni $PINS Y=nx12763 A0=camera_module_cache_ram_88__4 A1=nx35406
+ S0=nx34554
Xix25703 aoi22 $PINS Y=nx25702 A0=camera_module_cache_ram_120__4 A1=nx36056
+ B0=camera_module_cache_ram_104__4 B1=nx36096
Xcamera_module_cache_reg_ram_120__4 dffr $PINS Q=camera_module_cache_ram_120__4
+ QB=#dummy[418] D=nx12743 CLK=clk R=rst
Xix12744 mux21_ni $PINS Y=nx12743 A0=camera_module_cache_ram_120__4 A1=nx35406
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__4 dffr $PINS Q=camera_module_cache_ram_104__4
+ QB=#dummy[419] D=nx12753 CLK=clk R=rst
Xix12754 mux21_ni $PINS Y=nx12753 A0=camera_module_cache_ram_104__4 A1=nx35406
+ S0=nx34550
Xix15643 nand04 $PINS Y=nx15642 A0=nx25711 A1=nx25721 A2=nx25733 A3=nx25744
Xix25712 aoi22 $PINS Y=nx25711 A0=camera_module_cache_ram_136__4 A1=nx36136
+ B0=camera_module_cache_ram_152__4 B1=nx36176
Xcamera_module_cache_reg_ram_136__4 dffr $PINS Q=camera_module_cache_ram_136__4
+ QB=#dummy[420] D=nx12733 CLK=clk R=rst
Xix12734 mux21_ni $PINS Y=nx12733 A0=camera_module_cache_ram_136__4 A1=nx35406
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__4 dffr $PINS Q=camera_module_cache_ram_152__4
+ QB=#dummy[421] D=nx12723 CLK=clk R=rst
Xix12724 mux21_ni $PINS Y=nx12723 A0=camera_module_cache_ram_152__4 A1=nx35406
+ S0=nx34538
Xix25722 aoi22 $PINS Y=nx25721 A0=camera_module_cache_ram_184__4 A1=nx36216
+ B0=camera_module_cache_ram_168__4 B1=nx36256
Xcamera_module_cache_reg_ram_184__4 dffr $PINS Q=camera_module_cache_ram_184__4
+ QB=#dummy[422] D=nx12703 CLK=clk R=rst
Xix12704 mux21_ni $PINS Y=nx12703 A0=camera_module_cache_ram_184__4 A1=nx35406
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__4 dffr $PINS Q=camera_module_cache_ram_168__4
+ QB=#dummy[423] D=nx12713 CLK=clk R=rst
Xix12714 mux21_ni $PINS Y=nx12713 A0=camera_module_cache_ram_168__4 A1=nx35406
+ S0=nx34534
Xix25734 aoi22 $PINS Y=nx25733 A0=camera_module_cache_ram_200__4 A1=nx36296
+ B0=camera_module_cache_ram_216__4 B1=nx36336
Xcamera_module_cache_reg_ram_200__4 dffr $PINS Q=camera_module_cache_ram_200__4
+ QB=#dummy[424] D=nx12693 CLK=clk R=rst
Xix12694 mux21_ni $PINS Y=nx12693 A0=camera_module_cache_ram_200__4 A1=nx35408
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__4 dffr $PINS Q=camera_module_cache_ram_216__4
+ QB=#dummy[425] D=nx12683 CLK=clk R=rst
Xix12684 mux21_ni $PINS Y=nx12683 A0=camera_module_cache_ram_216__4 A1=nx35408
+ S0=nx34522
Xix25745 aoi22 $PINS Y=nx25744 A0=camera_module_cache_ram_232__4 A1=nx36376
+ B0=camera_module_cache_ram_248__4 B1=nx36416
Xcamera_module_cache_reg_ram_232__4 dffr $PINS Q=camera_module_cache_ram_232__4
+ QB=#dummy[426] D=nx12673 CLK=clk R=rst
Xix12674 mux21_ni $PINS Y=nx12673 A0=camera_module_cache_ram_232__4 A1=nx35408
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__4 dffr $PINS Q=camera_module_cache_ram_248__4
+ QB=#dummy[427] D=nx12663 CLK=clk R=rst
Xix12664 mux21_ni $PINS Y=nx12663 A0=camera_module_cache_ram_248__4 A1=nx35408
+ S0=nx34514
Xix25755 oai21 $PINS Y=nx25754 A0=nx15558 A1=nx15480 B0=nx36484
Xix15559 nand04 $PINS Y=nx15558 A0=nx25757 A1=nx25768 A2=nx25778 A3=nx25787
Xix25758 aoi22 $PINS Y=nx25757 A0=camera_module_cache_ram_9__4 A1=nx35816
+ B0=camera_module_cache_ram_25__4 B1=nx35856
Xcamera_module_cache_reg_ram_9__4 dffr $PINS Q=camera_module_cache_ram_9__4
+ QB=#dummy[428] D=nx12653 CLK=clk R=rst
Xix12654 mux21_ni $PINS Y=nx12653 A0=camera_module_cache_ram_9__4 A1=nx35408
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__4 dffr $PINS Q=camera_module_cache_ram_25__4
+ QB=#dummy[429] D=nx12643 CLK=clk R=rst
Xix12644 mux21_ni $PINS Y=nx12643 A0=camera_module_cache_ram_25__4 A1=nx35408
+ S0=nx34500
Xix25769 aoi22 $PINS Y=nx25768 A0=camera_module_cache_ram_41__4 A1=nx35896
+ B0=camera_module_cache_ram_57__4 B1=nx35936
Xcamera_module_cache_reg_ram_41__4 dffr $PINS Q=camera_module_cache_ram_41__4
+ QB=#dummy[430] D=nx12633 CLK=clk R=rst
Xix12634 mux21_ni $PINS Y=nx12633 A0=camera_module_cache_ram_41__4 A1=nx35408
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__4 dffr $PINS Q=camera_module_cache_ram_57__4
+ QB=#dummy[431] D=nx12623 CLK=clk R=rst
Xix12624 mux21_ni $PINS Y=nx12623 A0=camera_module_cache_ram_57__4 A1=nx35410
+ S0=nx34492
Xix25779 aoi22 $PINS Y=nx25778 A0=camera_module_cache_ram_73__4 A1=nx35976
+ B0=camera_module_cache_ram_89__4 B1=nx36016
Xcamera_module_cache_reg_ram_73__4 dffr $PINS Q=camera_module_cache_ram_73__4
+ QB=#dummy[432] D=nx12613 CLK=clk R=rst
Xix12614 mux21_ni $PINS Y=nx12613 A0=camera_module_cache_ram_73__4 A1=nx35410
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__4 dffr $PINS Q=camera_module_cache_ram_89__4
+ QB=#dummy[433] D=nx12603 CLK=clk R=rst
Xix12604 mux21_ni $PINS Y=nx12603 A0=camera_module_cache_ram_89__4 A1=nx35410
+ S0=nx34484
Xix25788 aoi22 $PINS Y=nx25787 A0=camera_module_cache_ram_121__4 A1=nx36056
+ B0=camera_module_cache_ram_105__4 B1=nx36096
Xcamera_module_cache_reg_ram_121__4 dffr $PINS Q=camera_module_cache_ram_121__4
+ QB=#dummy[434] D=nx12583 CLK=clk R=rst
Xix12584 mux21_ni $PINS Y=nx12583 A0=camera_module_cache_ram_121__4 A1=nx35410
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__4 dffr $PINS Q=camera_module_cache_ram_105__4
+ QB=#dummy[435] D=nx12593 CLK=clk R=rst
Xix12594 mux21_ni $PINS Y=nx12593 A0=camera_module_cache_ram_105__4 A1=nx35410
+ S0=nx34480
Xix15481 nand04 $PINS Y=nx15480 A0=nx25797 A1=nx25809 A2=nx25821 A3=nx25831
Xix25798 aoi22 $PINS Y=nx25797 A0=camera_module_cache_ram_137__4 A1=nx36136
+ B0=camera_module_cache_ram_153__4 B1=nx36176
Xcamera_module_cache_reg_ram_137__4 dffr $PINS Q=camera_module_cache_ram_137__4
+ QB=#dummy[436] D=nx12573 CLK=clk R=rst
Xix12574 mux21_ni $PINS Y=nx12573 A0=camera_module_cache_ram_137__4 A1=nx35410
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__4 dffr $PINS Q=camera_module_cache_ram_153__4
+ QB=#dummy[437] D=nx12563 CLK=clk R=rst
Xix12564 mux21_ni $PINS Y=nx12563 A0=camera_module_cache_ram_153__4 A1=nx35410
+ S0=nx34468
Xix25810 aoi22 $PINS Y=nx25809 A0=camera_module_cache_ram_185__4 A1=nx36216
+ B0=camera_module_cache_ram_169__4 B1=nx36256
Xcamera_module_cache_reg_ram_185__4 dffr $PINS Q=camera_module_cache_ram_185__4
+ QB=#dummy[438] D=nx12543 CLK=clk R=rst
Xix12544 mux21_ni $PINS Y=nx12543 A0=camera_module_cache_ram_185__4 A1=nx35412
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__4 dffr $PINS Q=camera_module_cache_ram_169__4
+ QB=#dummy[439] D=nx12553 CLK=clk R=rst
Xix12554 mux21_ni $PINS Y=nx12553 A0=camera_module_cache_ram_169__4 A1=nx35412
+ S0=nx34464
Xix25822 aoi22 $PINS Y=nx25821 A0=camera_module_cache_ram_201__4 A1=nx36296
+ B0=camera_module_cache_ram_217__4 B1=nx36336
Xcamera_module_cache_reg_ram_201__4 dffr $PINS Q=camera_module_cache_ram_201__4
+ QB=#dummy[440] D=nx12533 CLK=clk R=rst
Xix12534 mux21_ni $PINS Y=nx12533 A0=camera_module_cache_ram_201__4 A1=nx35412
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__4 dffr $PINS Q=camera_module_cache_ram_217__4
+ QB=#dummy[441] D=nx12523 CLK=clk R=rst
Xix12524 mux21_ni $PINS Y=nx12523 A0=camera_module_cache_ram_217__4 A1=nx35412
+ S0=nx34452
Xix25832 aoi22 $PINS Y=nx25831 A0=camera_module_cache_ram_233__4 A1=nx36376
+ B0=camera_module_cache_ram_249__4 B1=nx36416
Xcamera_module_cache_reg_ram_233__4 dffr $PINS Q=camera_module_cache_ram_233__4
+ QB=#dummy[442] D=nx12513 CLK=clk R=rst
Xix12514 mux21_ni $PINS Y=nx12513 A0=camera_module_cache_ram_233__4 A1=nx35412
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__4 dffr $PINS Q=camera_module_cache_ram_249__4
+ QB=#dummy[443] D=nx12503 CLK=clk R=rst
Xix12504 mux21_ni $PINS Y=nx12503 A0=camera_module_cache_ram_249__4 A1=nx35412
+ S0=nx34444
Xix25843 oai21 $PINS Y=nx25842 A0=nx15394 A1=nx15316 B0=nx36488
Xix15395 nand04 $PINS Y=nx15394 A0=nx25845 A1=nx25855 A2=nx25864 A3=nx25872
Xix25846 aoi22 $PINS Y=nx25845 A0=camera_module_cache_ram_10__4 A1=nx35816
+ B0=camera_module_cache_ram_26__4 B1=nx35856
Xcamera_module_cache_reg_ram_10__4 dffr $PINS Q=camera_module_cache_ram_10__4
+ QB=#dummy[444] D=nx12493 CLK=clk R=rst
Xix12494 mux21_ni $PINS Y=nx12493 A0=camera_module_cache_ram_10__4 A1=nx35412
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__4 dffr $PINS Q=camera_module_cache_ram_26__4
+ QB=#dummy[445] D=nx12483 CLK=clk R=rst
Xix12484 mux21_ni $PINS Y=nx12483 A0=camera_module_cache_ram_26__4 A1=nx35414
+ S0=nx34430
Xix25856 aoi22 $PINS Y=nx25855 A0=camera_module_cache_ram_42__4 A1=nx35896
+ B0=camera_module_cache_ram_58__4 B1=nx35936
Xcamera_module_cache_reg_ram_42__4 dffr $PINS Q=camera_module_cache_ram_42__4
+ QB=#dummy[446] D=nx12473 CLK=clk R=rst
Xix12474 mux21_ni $PINS Y=nx12473 A0=camera_module_cache_ram_42__4 A1=nx35414
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__4 dffr $PINS Q=camera_module_cache_ram_58__4
+ QB=#dummy[447] D=nx12463 CLK=clk R=rst
Xix12464 mux21_ni $PINS Y=nx12463 A0=camera_module_cache_ram_58__4 A1=nx35414
+ S0=nx34422
Xix25865 aoi22 $PINS Y=nx25864 A0=camera_module_cache_ram_74__4 A1=nx35976
+ B0=camera_module_cache_ram_90__4 B1=nx36016
Xcamera_module_cache_reg_ram_74__4 dffr $PINS Q=camera_module_cache_ram_74__4
+ QB=#dummy[448] D=nx12453 CLK=clk R=rst
Xix12454 mux21_ni $PINS Y=nx12453 A0=camera_module_cache_ram_74__4 A1=nx35414
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__4 dffr $PINS Q=camera_module_cache_ram_90__4
+ QB=#dummy[449] D=nx12443 CLK=clk R=rst
Xix12444 mux21_ni $PINS Y=nx12443 A0=camera_module_cache_ram_90__4 A1=nx35414
+ S0=nx34414
Xix25874 aoi22 $PINS Y=nx25872 A0=camera_module_cache_ram_122__4 A1=nx36056
+ B0=camera_module_cache_ram_106__4 B1=nx36096
Xcamera_module_cache_reg_ram_122__4 dffr $PINS Q=camera_module_cache_ram_122__4
+ QB=#dummy[450] D=nx12423 CLK=clk R=rst
Xix12424 mux21_ni $PINS Y=nx12423 A0=camera_module_cache_ram_122__4 A1=nx35414
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__4 dffr $PINS Q=camera_module_cache_ram_106__4
+ QB=#dummy[451] D=nx12433 CLK=clk R=rst
Xix12434 mux21_ni $PINS Y=nx12433 A0=camera_module_cache_ram_106__4 A1=nx35414
+ S0=nx34410
Xix15317 nand04 $PINS Y=nx15316 A0=nx25885 A1=nx25895 A2=nx25905 A3=nx25916
Xix25886 aoi22 $PINS Y=nx25885 A0=camera_module_cache_ram_138__4 A1=nx36136
+ B0=camera_module_cache_ram_154__4 B1=nx36176
Xcamera_module_cache_reg_ram_138__4 dffr $PINS Q=camera_module_cache_ram_138__4
+ QB=#dummy[452] D=nx12413 CLK=clk R=rst
Xix12414 mux21_ni $PINS Y=nx12413 A0=camera_module_cache_ram_138__4 A1=nx35416
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__4 dffr $PINS Q=camera_module_cache_ram_154__4
+ QB=#dummy[453] D=nx12403 CLK=clk R=rst
Xix12404 mux21_ni $PINS Y=nx12403 A0=camera_module_cache_ram_154__4 A1=nx35416
+ S0=nx34398
Xix25896 aoi22 $PINS Y=nx25895 A0=camera_module_cache_ram_186__4 A1=nx36216
+ B0=camera_module_cache_ram_170__4 B1=nx36256
Xcamera_module_cache_reg_ram_186__4 dffr $PINS Q=camera_module_cache_ram_186__4
+ QB=#dummy[454] D=nx12383 CLK=clk R=rst
Xix12384 mux21_ni $PINS Y=nx12383 A0=camera_module_cache_ram_186__4 A1=nx35416
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__4 dffr $PINS Q=camera_module_cache_ram_170__4
+ QB=#dummy[455] D=nx12393 CLK=clk R=rst
Xix12394 mux21_ni $PINS Y=nx12393 A0=camera_module_cache_ram_170__4 A1=nx35416
+ S0=nx34394
Xix25906 aoi22 $PINS Y=nx25905 A0=camera_module_cache_ram_202__4 A1=nx36296
+ B0=camera_module_cache_ram_218__4 B1=nx36336
Xcamera_module_cache_reg_ram_202__4 dffr $PINS Q=camera_module_cache_ram_202__4
+ QB=#dummy[456] D=nx12373 CLK=clk R=rst
Xix12374 mux21_ni $PINS Y=nx12373 A0=camera_module_cache_ram_202__4 A1=nx35416
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__4 dffr $PINS Q=camera_module_cache_ram_218__4
+ QB=#dummy[457] D=nx12363 CLK=clk R=rst
Xix12364 mux21_ni $PINS Y=nx12363 A0=camera_module_cache_ram_218__4 A1=nx35416
+ S0=nx34382
Xix25917 aoi22 $PINS Y=nx25916 A0=camera_module_cache_ram_234__4 A1=nx36376
+ B0=camera_module_cache_ram_250__4 B1=nx36416
Xcamera_module_cache_reg_ram_234__4 dffr $PINS Q=camera_module_cache_ram_234__4
+ QB=#dummy[458] D=nx12353 CLK=clk R=rst
Xix12354 mux21_ni $PINS Y=nx12353 A0=camera_module_cache_ram_234__4 A1=nx35416
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__4 dffr $PINS Q=camera_module_cache_ram_250__4
+ QB=#dummy[459] D=nx12343 CLK=clk R=rst
Xix12344 mux21_ni $PINS Y=nx12343 A0=camera_module_cache_ram_250__4 A1=nx35418
+ S0=nx34374
Xix25927 oai21 $PINS Y=nx25926 A0=nx15232 A1=nx15154 B0=nx36492
Xix15233 nand04 $PINS Y=nx15232 A0=nx25929 A1=nx25938 A2=nx25946 A3=nx25959
Xix25930 aoi22 $PINS Y=nx25929 A0=camera_module_cache_ram_11__4 A1=nx35816
+ B0=camera_module_cache_ram_27__4 B1=nx35856
Xcamera_module_cache_reg_ram_11__4 dffr $PINS Q=camera_module_cache_ram_11__4
+ QB=#dummy[460] D=nx12333 CLK=clk R=rst
Xix12334 mux21_ni $PINS Y=nx12333 A0=camera_module_cache_ram_11__4 A1=nx35418
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__4 dffr $PINS Q=camera_module_cache_ram_27__4
+ QB=#dummy[461] D=nx12323 CLK=clk R=rst
Xix12324 mux21_ni $PINS Y=nx12323 A0=camera_module_cache_ram_27__4 A1=nx35418
+ S0=nx34360
Xix25939 aoi22 $PINS Y=nx25938 A0=camera_module_cache_ram_43__4 A1=nx35896
+ B0=camera_module_cache_ram_59__4 B1=nx35936
Xcamera_module_cache_reg_ram_43__4 dffr $PINS Q=camera_module_cache_ram_43__4
+ QB=#dummy[462] D=nx12313 CLK=clk R=rst
Xix12314 mux21_ni $PINS Y=nx12313 A0=camera_module_cache_ram_43__4 A1=nx35418
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__4 dffr $PINS Q=camera_module_cache_ram_59__4
+ QB=#dummy[463] D=nx12303 CLK=clk R=rst
Xix12304 mux21_ni $PINS Y=nx12303 A0=camera_module_cache_ram_59__4 A1=nx35418
+ S0=nx34352
Xix25948 aoi22 $PINS Y=nx25946 A0=camera_module_cache_ram_75__4 A1=nx35976
+ B0=camera_module_cache_ram_91__4 B1=nx36016
Xcamera_module_cache_reg_ram_75__4 dffr $PINS Q=camera_module_cache_ram_75__4
+ QB=#dummy[464] D=nx12293 CLK=clk R=rst
Xix12294 mux21_ni $PINS Y=nx12293 A0=camera_module_cache_ram_75__4 A1=nx35418
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__4 dffr $PINS Q=camera_module_cache_ram_91__4
+ QB=#dummy[465] D=nx12283 CLK=clk R=rst
Xix12284 mux21_ni $PINS Y=nx12283 A0=camera_module_cache_ram_91__4 A1=nx35418
+ S0=nx34344
Xix25960 aoi22 $PINS Y=nx25959 A0=camera_module_cache_ram_123__4 A1=nx36056
+ B0=camera_module_cache_ram_107__4 B1=nx36096
Xcamera_module_cache_reg_ram_123__4 dffr $PINS Q=camera_module_cache_ram_123__4
+ QB=#dummy[466] D=nx12263 CLK=clk R=rst
Xix12264 mux21_ni $PINS Y=nx12263 A0=camera_module_cache_ram_123__4 A1=nx35420
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__4 dffr $PINS Q=camera_module_cache_ram_107__4
+ QB=#dummy[467] D=nx12273 CLK=clk R=rst
Xix12274 mux21_ni $PINS Y=nx12273 A0=camera_module_cache_ram_107__4 A1=nx35420
+ S0=nx34340
Xix15155 nand04 $PINS Y=nx15154 A0=nx25969 A1=nx25979 A2=nx25990 A3=nx26000
Xix25970 aoi22 $PINS Y=nx25969 A0=camera_module_cache_ram_139__4 A1=nx36136
+ B0=camera_module_cache_ram_155__4 B1=nx36176
Xcamera_module_cache_reg_ram_139__4 dffr $PINS Q=camera_module_cache_ram_139__4
+ QB=#dummy[468] D=nx12253 CLK=clk R=rst
Xix12254 mux21_ni $PINS Y=nx12253 A0=camera_module_cache_ram_139__4 A1=nx35420
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__4 dffr $PINS Q=camera_module_cache_ram_155__4
+ QB=#dummy[469] D=nx12243 CLK=clk R=rst
Xix12244 mux21_ni $PINS Y=nx12243 A0=camera_module_cache_ram_155__4 A1=nx35420
+ S0=nx34328
Xix25980 aoi22 $PINS Y=nx25979 A0=camera_module_cache_ram_187__4 A1=nx36216
+ B0=camera_module_cache_ram_171__4 B1=nx36256
Xcamera_module_cache_reg_ram_187__4 dffr $PINS Q=camera_module_cache_ram_187__4
+ QB=#dummy[470] D=nx12223 CLK=clk R=rst
Xix12224 mux21_ni $PINS Y=nx12223 A0=camera_module_cache_ram_187__4 A1=nx35420
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__4 dffr $PINS Q=camera_module_cache_ram_171__4
+ QB=#dummy[471] D=nx12233 CLK=clk R=rst
Xix12234 mux21_ni $PINS Y=nx12233 A0=camera_module_cache_ram_171__4 A1=nx35420
+ S0=nx34324
Xix25991 aoi22 $PINS Y=nx25990 A0=camera_module_cache_ram_203__4 A1=nx36296
+ B0=camera_module_cache_ram_219__4 B1=nx36336
Xcamera_module_cache_reg_ram_203__4 dffr $PINS Q=camera_module_cache_ram_203__4
+ QB=#dummy[472] D=nx12213 CLK=clk R=rst
Xix12214 mux21_ni $PINS Y=nx12213 A0=camera_module_cache_ram_203__4 A1=nx35420
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__4 dffr $PINS Q=camera_module_cache_ram_219__4
+ QB=#dummy[473] D=nx12203 CLK=clk R=rst
Xix12204 mux21_ni $PINS Y=nx12203 A0=camera_module_cache_ram_219__4 A1=nx35422
+ S0=nx34312
Xix26001 aoi22 $PINS Y=nx26000 A0=camera_module_cache_ram_235__4 A1=nx36376
+ B0=camera_module_cache_ram_251__4 B1=nx36416
Xcamera_module_cache_reg_ram_235__4 dffr $PINS Q=camera_module_cache_ram_235__4
+ QB=#dummy[474] D=nx12193 CLK=clk R=rst
Xix12194 mux21_ni $PINS Y=nx12193 A0=camera_module_cache_ram_235__4 A1=nx35422
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__4 dffr $PINS Q=camera_module_cache_ram_251__4
+ QB=#dummy[475] D=nx12183 CLK=clk R=rst
Xix12184 mux21_ni $PINS Y=nx12183 A0=camera_module_cache_ram_251__4 A1=nx35422
+ S0=nx34304
Xix15077 nand04 $PINS Y=nx15076 A0=nx26009 A1=nx26094 A2=nx26185 A3=nx26272
Xix26010 oai21 $PINS Y=nx26009 A0=nx15066 A1=nx14988 B0=nx36506
Xix15067 nand04 $PINS Y=nx15066 A0=nx26013 A1=nx26023 A2=nx26034 A3=nx26045
Xix26014 aoi22 $PINS Y=nx26013 A0=camera_module_cache_ram_12__4 A1=nx35816
+ B0=camera_module_cache_ram_28__4 B1=nx35856
Xcamera_module_cache_reg_ram_12__4 dffr $PINS Q=camera_module_cache_ram_12__4
+ QB=#dummy[476] D=nx12173 CLK=clk R=rst
Xix12174 mux21_ni $PINS Y=nx12173 A0=nx35422 A1=camera_module_cache_ram_12__4
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__4 dffr $PINS Q=camera_module_cache_ram_28__4
+ QB=#dummy[477] D=nx12163 CLK=clk R=rst
Xix12164 mux21_ni $PINS Y=nx12163 A0=nx35422 A1=camera_module_cache_ram_28__4
+ S0=nx36510
Xix26024 aoi22 $PINS Y=nx26023 A0=camera_module_cache_ram_44__4 A1=nx35896
+ B0=camera_module_cache_ram_60__4 B1=nx35936
Xcamera_module_cache_reg_ram_44__4 dffr $PINS Q=camera_module_cache_ram_44__4
+ QB=#dummy[478] D=nx12153 CLK=clk R=rst
Xix12154 mux21_ni $PINS Y=nx12153 A0=nx35422 A1=camera_module_cache_ram_44__4
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__4 dffr $PINS Q=camera_module_cache_ram_60__4
+ QB=#dummy[479] D=nx12143 CLK=clk R=rst
Xix12144 mux21_ni $PINS Y=nx12143 A0=nx35422 A1=camera_module_cache_ram_60__4
+ S0=nx36518
Xix26035 aoi22 $PINS Y=nx26034 A0=camera_module_cache_ram_76__4 A1=nx35976
+ B0=camera_module_cache_ram_92__4 B1=nx36016
Xcamera_module_cache_reg_ram_76__4 dffr $PINS Q=camera_module_cache_ram_76__4
+ QB=#dummy[480] D=nx12133 CLK=clk R=rst
Xix12134 mux21_ni $PINS Y=nx12133 A0=nx35424 A1=camera_module_cache_ram_76__4
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__4 dffr $PINS Q=camera_module_cache_ram_92__4
+ QB=#dummy[481] D=nx12123 CLK=clk R=rst
Xix12124 mux21_ni $PINS Y=nx12123 A0=nx35424 A1=camera_module_cache_ram_92__4
+ S0=nx36526
Xix26046 aoi22 $PINS Y=nx26045 A0=camera_module_cache_ram_124__4 A1=nx36056
+ B0=camera_module_cache_ram_108__4 B1=nx36096
Xcamera_module_cache_reg_ram_124__4 dffr $PINS Q=camera_module_cache_ram_124__4
+ QB=#dummy[482] D=nx12103 CLK=clk R=rst
Xix12104 mux21_ni $PINS Y=nx12103 A0=nx35424 A1=camera_module_cache_ram_124__4
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__4 dffr $PINS Q=camera_module_cache_ram_108__4
+ QB=#dummy[483] D=nx12113 CLK=clk R=rst
Xix12114 mux21_ni $PINS Y=nx12113 A0=nx35424 A1=camera_module_cache_ram_108__4
+ S0=nx36534
Xix14989 nand04 $PINS Y=nx14988 A0=nx26055 A1=nx26067 A2=nx26077 A3=nx26086
Xix26056 aoi22 $PINS Y=nx26055 A0=camera_module_cache_ram_140__4 A1=nx36136
+ B0=camera_module_cache_ram_156__4 B1=nx36176
Xcamera_module_cache_reg_ram_140__4 dffr $PINS Q=camera_module_cache_ram_140__4
+ QB=#dummy[484] D=nx12093 CLK=clk R=rst
Xix12094 mux21_ni $PINS Y=nx12093 A0=nx35424 A1=camera_module_cache_ram_140__4
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__4 dffr $PINS Q=camera_module_cache_ram_156__4
+ QB=#dummy[485] D=nx12083 CLK=clk R=rst
Xix12084 mux21_ni $PINS Y=nx12083 A0=nx35424 A1=camera_module_cache_ram_156__4
+ S0=nx36542
Xix26068 aoi22 $PINS Y=nx26067 A0=camera_module_cache_ram_188__4 A1=nx36216
+ B0=camera_module_cache_ram_172__4 B1=nx36256
Xcamera_module_cache_reg_ram_188__4 dffr $PINS Q=camera_module_cache_ram_188__4
+ QB=#dummy[486] D=nx12063 CLK=clk R=rst
Xix12064 mux21_ni $PINS Y=nx12063 A0=nx35424 A1=camera_module_cache_ram_188__4
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__4 dffr $PINS Q=camera_module_cache_ram_172__4
+ QB=#dummy[487] D=nx12073 CLK=clk R=rst
Xix12074 mux21_ni $PINS Y=nx12073 A0=nx35426 A1=camera_module_cache_ram_172__4
+ S0=nx36550
Xix26078 aoi22 $PINS Y=nx26077 A0=camera_module_cache_ram_204__4 A1=nx36296
+ B0=camera_module_cache_ram_220__4 B1=nx36336
Xcamera_module_cache_reg_ram_204__4 dffr $PINS Q=camera_module_cache_ram_204__4
+ QB=#dummy[488] D=nx12053 CLK=clk R=rst
Xix12054 mux21_ni $PINS Y=nx12053 A0=nx35426 A1=camera_module_cache_ram_204__4
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__4 dffr $PINS Q=camera_module_cache_ram_220__4
+ QB=#dummy[489] D=nx12043 CLK=clk R=rst
Xix12044 mux21_ni $PINS Y=nx12043 A0=nx35426 A1=camera_module_cache_ram_220__4
+ S0=nx36558
Xix26087 aoi22 $PINS Y=nx26086 A0=camera_module_cache_ram_236__4 A1=nx36376
+ B0=camera_module_cache_ram_252__4 B1=nx36416
Xcamera_module_cache_reg_ram_236__4 dffr $PINS Q=camera_module_cache_ram_236__4
+ QB=#dummy[490] D=nx12033 CLK=clk R=rst
Xix12034 mux21_ni $PINS Y=nx12033 A0=nx35426 A1=camera_module_cache_ram_236__4
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__4 dffr $PINS Q=camera_module_cache_ram_252__4
+ QB=#dummy[491] D=nx12023 CLK=clk R=rst
Xix12024 mux21_ni $PINS Y=nx12023 A0=nx35426 A1=camera_module_cache_ram_252__4
+ S0=nx36566
Xix26096 oai21 $PINS Y=nx26094 A0=nx14904 A1=nx14826 B0=nx36580
Xix14905 nand04 $PINS Y=nx14904 A0=nx26099 A1=nx26111 A2=nx26122 A3=nx26131
Xix26100 aoi22 $PINS Y=nx26099 A0=camera_module_cache_ram_13__4 A1=nx35816
+ B0=camera_module_cache_ram_29__4 B1=nx35856
Xcamera_module_cache_reg_ram_13__4 dffr $PINS Q=camera_module_cache_ram_13__4
+ QB=#dummy[492] D=nx12013 CLK=clk R=rst
Xix12014 mux21_ni $PINS Y=nx12013 A0=nx35426 A1=camera_module_cache_ram_13__4
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__4 dffr $PINS Q=camera_module_cache_ram_29__4
+ QB=#dummy[493] D=nx12003 CLK=clk R=rst
Xix12004 mux21_ni $PINS Y=nx12003 A0=nx35426 A1=camera_module_cache_ram_29__4
+ S0=nx36584
Xix26112 aoi22 $PINS Y=nx26111 A0=camera_module_cache_ram_45__4 A1=nx35896
+ B0=camera_module_cache_ram_61__4 B1=nx35936
Xcamera_module_cache_reg_ram_45__4 dffr $PINS Q=camera_module_cache_ram_45__4
+ QB=#dummy[494] D=nx11993 CLK=clk R=rst
Xix11994 mux21_ni $PINS Y=nx11993 A0=nx35428 A1=camera_module_cache_ram_45__4
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__4 dffr $PINS Q=camera_module_cache_ram_61__4
+ QB=#dummy[495] D=nx11983 CLK=clk R=rst
Xix11984 mux21_ni $PINS Y=nx11983 A0=nx35428 A1=camera_module_cache_ram_61__4
+ S0=nx36592
Xix26123 aoi22 $PINS Y=nx26122 A0=camera_module_cache_ram_77__4 A1=nx35976
+ B0=camera_module_cache_ram_93__4 B1=nx36016
Xcamera_module_cache_reg_ram_77__4 dffr $PINS Q=camera_module_cache_ram_77__4
+ QB=#dummy[496] D=nx11973 CLK=clk R=rst
Xix11974 mux21_ni $PINS Y=nx11973 A0=nx35428 A1=camera_module_cache_ram_77__4
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__4 dffr $PINS Q=camera_module_cache_ram_93__4
+ QB=#dummy[497] D=nx11963 CLK=clk R=rst
Xix11964 mux21_ni $PINS Y=nx11963 A0=nx35428 A1=camera_module_cache_ram_93__4
+ S0=nx36600
Xix26132 aoi22 $PINS Y=nx26131 A0=camera_module_cache_ram_125__4 A1=nx36056
+ B0=camera_module_cache_ram_109__4 B1=nx36096
Xcamera_module_cache_reg_ram_125__4 dffr $PINS Q=camera_module_cache_ram_125__4
+ QB=#dummy[498] D=nx11943 CLK=clk R=rst
Xix11944 mux21_ni $PINS Y=nx11943 A0=nx35428 A1=camera_module_cache_ram_125__4
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__4 dffr $PINS Q=camera_module_cache_ram_109__4
+ QB=#dummy[499] D=nx11953 CLK=clk R=rst
Xix11954 mux21_ni $PINS Y=nx11953 A0=nx35428 A1=camera_module_cache_ram_109__4
+ S0=nx36608
Xix14827 nand04 $PINS Y=nx14826 A0=nx26143 A1=nx26152 A2=nx26162 A3=nx26173
Xix26144 aoi22 $PINS Y=nx26143 A0=camera_module_cache_ram_141__4 A1=nx36136
+ B0=camera_module_cache_ram_157__4 B1=nx36176
Xcamera_module_cache_reg_ram_141__4 dffr $PINS Q=camera_module_cache_ram_141__4
+ QB=#dummy[500] D=nx11933 CLK=clk R=rst
Xix11934 mux21_ni $PINS Y=nx11933 A0=nx35428 A1=camera_module_cache_ram_141__4
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__4 dffr $PINS Q=camera_module_cache_ram_157__4
+ QB=#dummy[501] D=nx11923 CLK=clk R=rst
Xix11924 mux21_ni $PINS Y=nx11923 A0=nx35430 A1=camera_module_cache_ram_157__4
+ S0=nx36616
Xix26153 aoi22 $PINS Y=nx26152 A0=camera_module_cache_ram_189__4 A1=nx36216
+ B0=camera_module_cache_ram_173__4 B1=nx36256
Xcamera_module_cache_reg_ram_189__4 dffr $PINS Q=camera_module_cache_ram_189__4
+ QB=#dummy[502] D=nx11903 CLK=clk R=rst
Xix11904 mux21_ni $PINS Y=nx11903 A0=nx35430 A1=camera_module_cache_ram_189__4
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__4 dffr $PINS Q=camera_module_cache_ram_173__4
+ QB=#dummy[503] D=nx11913 CLK=clk R=rst
Xix11914 mux21_ni $PINS Y=nx11913 A0=nx35430 A1=camera_module_cache_ram_173__4
+ S0=nx36624
Xix26163 aoi22 $PINS Y=nx26162 A0=camera_module_cache_ram_205__4 A1=nx36296
+ B0=camera_module_cache_ram_221__4 B1=nx36336
Xcamera_module_cache_reg_ram_205__4 dffr $PINS Q=camera_module_cache_ram_205__4
+ QB=#dummy[504] D=nx11893 CLK=clk R=rst
Xix11894 mux21_ni $PINS Y=nx11893 A0=nx35430 A1=camera_module_cache_ram_205__4
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__4 dffr $PINS Q=camera_module_cache_ram_221__4
+ QB=#dummy[505] D=nx11883 CLK=clk R=rst
Xix11884 mux21_ni $PINS Y=nx11883 A0=nx35430 A1=camera_module_cache_ram_221__4
+ S0=nx36632
Xix26174 aoi22 $PINS Y=nx26173 A0=camera_module_cache_ram_237__4 A1=nx36376
+ B0=camera_module_cache_ram_253__4 B1=nx36416
Xcamera_module_cache_reg_ram_237__4 dffr $PINS Q=camera_module_cache_ram_237__4
+ QB=#dummy[506] D=nx11873 CLK=clk R=rst
Xix11874 mux21_ni $PINS Y=nx11873 A0=nx35430 A1=camera_module_cache_ram_237__4
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__4 dffr $PINS Q=camera_module_cache_ram_253__4
+ QB=#dummy[507] D=nx11863 CLK=clk R=rst
Xix11864 mux21_ni $PINS Y=nx11863 A0=nx35430 A1=camera_module_cache_ram_253__4
+ S0=nx36640
Xix26186 oai21 $PINS Y=nx26185 A0=nx14740 A1=nx14662 B0=nx36654
Xix14741 nand04 $PINS Y=nx14740 A0=nx26189 A1=nx26199 A2=nx26209 A3=nx26220
Xix26190 aoi22 $PINS Y=nx26189 A0=camera_module_cache_ram_14__4 A1=nx35816
+ B0=camera_module_cache_ram_30__4 B1=nx35856
Xcamera_module_cache_reg_ram_14__4 dffr $PINS Q=camera_module_cache_ram_14__4
+ QB=#dummy[508] D=nx11853 CLK=clk R=rst
Xix11854 mux21_ni $PINS Y=nx11853 A0=nx35432 A1=camera_module_cache_ram_14__4
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__4 dffr $PINS Q=camera_module_cache_ram_30__4
+ QB=#dummy[509] D=nx11843 CLK=clk R=rst
Xix11844 mux21_ni $PINS Y=nx11843 A0=nx35432 A1=camera_module_cache_ram_30__4
+ S0=nx36658
Xix26200 aoi22 $PINS Y=nx26199 A0=camera_module_cache_ram_46__4 A1=nx35896
+ B0=camera_module_cache_ram_62__4 B1=nx35936
Xcamera_module_cache_reg_ram_46__4 dffr $PINS Q=camera_module_cache_ram_46__4
+ QB=#dummy[510] D=nx11833 CLK=clk R=rst
Xix11834 mux21_ni $PINS Y=nx11833 A0=nx35432 A1=camera_module_cache_ram_46__4
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__4 dffr $PINS Q=camera_module_cache_ram_62__4
+ QB=#dummy[511] D=nx11823 CLK=clk R=rst
Xix11824 mux21_ni $PINS Y=nx11823 A0=nx35432 A1=camera_module_cache_ram_62__4
+ S0=nx36666
Xix26210 aoi22 $PINS Y=nx26209 A0=camera_module_cache_ram_78__4 A1=nx35976
+ B0=camera_module_cache_ram_94__4 B1=nx36016
Xcamera_module_cache_reg_ram_78__4 dffr $PINS Q=camera_module_cache_ram_78__4
+ QB=#dummy[512] D=nx11813 CLK=clk R=rst
Xix11814 mux21_ni $PINS Y=nx11813 A0=nx35432 A1=camera_module_cache_ram_78__4
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__4 dffr $PINS Q=camera_module_cache_ram_94__4
+ QB=#dummy[513] D=nx11803 CLK=clk R=rst
Xix11804 mux21_ni $PINS Y=nx11803 A0=nx35432 A1=camera_module_cache_ram_94__4
+ S0=nx36674
Xix26221 aoi22 $PINS Y=nx26220 A0=camera_module_cache_ram_126__4 A1=nx36056
+ B0=camera_module_cache_ram_110__4 B1=nx36096
Xcamera_module_cache_reg_ram_126__4 dffr $PINS Q=camera_module_cache_ram_126__4
+ QB=#dummy[514] D=nx11783 CLK=clk R=rst
Xix11784 mux21_ni $PINS Y=nx11783 A0=nx35432 A1=camera_module_cache_ram_126__4
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__4 dffr $PINS Q=camera_module_cache_ram_110__4
+ QB=#dummy[515] D=nx11793 CLK=clk R=rst
Xix11794 mux21_ni $PINS Y=nx11793 A0=nx35434 A1=camera_module_cache_ram_110__4
+ S0=nx36682
Xix14663 nand04 $PINS Y=nx14662 A0=nx26229 A1=nx26239 A2=nx26251 A3=nx26262
Xix26230 aoi22 $PINS Y=nx26229 A0=camera_module_cache_ram_142__4 A1=nx36136
+ B0=camera_module_cache_ram_158__4 B1=nx36176
Xcamera_module_cache_reg_ram_142__4 dffr $PINS Q=camera_module_cache_ram_142__4
+ QB=#dummy[516] D=nx11773 CLK=clk R=rst
Xix11774 mux21_ni $PINS Y=nx11773 A0=nx35434 A1=camera_module_cache_ram_142__4
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__4 dffr $PINS Q=camera_module_cache_ram_158__4
+ QB=#dummy[517] D=nx11763 CLK=clk R=rst
Xix11764 mux21_ni $PINS Y=nx11763 A0=nx35434 A1=camera_module_cache_ram_158__4
+ S0=nx36690
Xix26240 aoi22 $PINS Y=nx26239 A0=camera_module_cache_ram_190__4 A1=nx36216
+ B0=camera_module_cache_ram_174__4 B1=nx36256
Xcamera_module_cache_reg_ram_190__4 dffr $PINS Q=camera_module_cache_ram_190__4
+ QB=#dummy[518] D=nx11743 CLK=clk R=rst
Xix11744 mux21_ni $PINS Y=nx11743 A0=nx35434 A1=camera_module_cache_ram_190__4
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__4 dffr $PINS Q=camera_module_cache_ram_174__4
+ QB=#dummy[519] D=nx11753 CLK=clk R=rst
Xix11754 mux21_ni $PINS Y=nx11753 A0=nx35434 A1=camera_module_cache_ram_174__4
+ S0=nx36698
Xix26252 aoi22 $PINS Y=nx26251 A0=camera_module_cache_ram_206__4 A1=nx36296
+ B0=camera_module_cache_ram_222__4 B1=nx36336
Xcamera_module_cache_reg_ram_206__4 dffr $PINS Q=camera_module_cache_ram_206__4
+ QB=#dummy[520] D=nx11733 CLK=clk R=rst
Xix11734 mux21_ni $PINS Y=nx11733 A0=nx35434 A1=camera_module_cache_ram_206__4
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__4 dffr $PINS Q=camera_module_cache_ram_222__4
+ QB=#dummy[521] D=nx11723 CLK=clk R=rst
Xix11724 mux21_ni $PINS Y=nx11723 A0=nx35434 A1=camera_module_cache_ram_222__4
+ S0=nx36706
Xix26263 aoi22 $PINS Y=nx26262 A0=camera_module_cache_ram_238__4 A1=nx36376
+ B0=camera_module_cache_ram_254__4 B1=nx36416
Xcamera_module_cache_reg_ram_238__4 dffr $PINS Q=camera_module_cache_ram_238__4
+ QB=#dummy[522] D=nx11713 CLK=clk R=rst
Xix11714 mux21_ni $PINS Y=nx11713 A0=nx35436 A1=camera_module_cache_ram_238__4
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__4 dffr $PINS Q=camera_module_cache_ram_254__4
+ QB=#dummy[523] D=nx11703 CLK=clk R=rst
Xix11704 mux21_ni $PINS Y=nx11703 A0=nx35436 A1=camera_module_cache_ram_254__4
+ S0=nx36714
Xix26273 oai21 $PINS Y=nx26272 A0=nx14578 A1=nx14500 B0=nx36728
Xix14579 nand04 $PINS Y=nx14578 A0=nx26275 A1=nx26286 A2=nx26296 A3=nx26305
Xix26276 aoi22 $PINS Y=nx26275 A0=camera_module_cache_ram_15__4 A1=nx35818
+ B0=camera_module_cache_ram_31__4 B1=nx35858
Xcamera_module_cache_reg_ram_15__4 dffr $PINS Q=camera_module_cache_ram_15__4
+ QB=#dummy[524] D=nx11693 CLK=clk R=rst
Xix11694 mux21_ni $PINS Y=nx11693 A0=nx35436 A1=camera_module_cache_ram_15__4
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__4 dffr $PINS Q=camera_module_cache_ram_31__4
+ QB=#dummy[525] D=nx11683 CLK=clk R=rst
Xix11684 mux21_ni $PINS Y=nx11683 A0=nx35436 A1=camera_module_cache_ram_31__4
+ S0=nx36732
Xix26287 aoi22 $PINS Y=nx26286 A0=camera_module_cache_ram_47__4 A1=nx35898
+ B0=camera_module_cache_ram_63__4 B1=nx35938
Xcamera_module_cache_reg_ram_47__4 dffr $PINS Q=camera_module_cache_ram_47__4
+ QB=#dummy[526] D=nx11673 CLK=clk R=rst
Xix11674 mux21_ni $PINS Y=nx11673 A0=nx35436 A1=camera_module_cache_ram_47__4
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__4 dffr $PINS Q=camera_module_cache_ram_63__4
+ QB=#dummy[527] D=nx11663 CLK=clk R=rst
Xix11664 mux21_ni $PINS Y=nx11663 A0=nx35436 A1=camera_module_cache_ram_63__4
+ S0=nx36740
Xix26297 aoi22 $PINS Y=nx26296 A0=camera_module_cache_ram_79__4 A1=nx35978
+ B0=camera_module_cache_ram_95__4 B1=nx36018
Xcamera_module_cache_reg_ram_79__4 dffr $PINS Q=camera_module_cache_ram_79__4
+ QB=#dummy[528] D=nx11653 CLK=clk R=rst
Xix11654 mux21_ni $PINS Y=nx11653 A0=nx35436 A1=camera_module_cache_ram_79__4
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__4 dffr $PINS Q=camera_module_cache_ram_95__4
+ QB=#dummy[529] D=nx11643 CLK=clk R=rst
Xix11644 mux21_ni $PINS Y=nx11643 A0=nx35438 A1=camera_module_cache_ram_95__4
+ S0=nx36748
Xix26306 aoi22 $PINS Y=nx26305 A0=camera_module_cache_ram_127__4 A1=nx36058
+ B0=camera_module_cache_ram_111__4 B1=nx36098
Xcamera_module_cache_reg_ram_127__4 dffr $PINS Q=camera_module_cache_ram_127__4
+ QB=#dummy[530] D=nx11623 CLK=clk R=rst
Xix11624 mux21_ni $PINS Y=nx11623 A0=nx35438 A1=camera_module_cache_ram_127__4
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__4 dffr $PINS Q=camera_module_cache_ram_111__4
+ QB=#dummy[531] D=nx11633 CLK=clk R=rst
Xix11634 mux21_ni $PINS Y=nx11633 A0=nx35438 A1=camera_module_cache_ram_111__4
+ S0=nx36756
Xix14501 nand04 $PINS Y=nx14500 A0=nx26315 A1=nx26327 A2=nx26339 A3=nx26349
Xix26316 aoi22 $PINS Y=nx26315 A0=camera_module_cache_ram_143__4 A1=nx36138
+ B0=camera_module_cache_ram_159__4 B1=nx36178
Xcamera_module_cache_reg_ram_143__4 dffr $PINS Q=camera_module_cache_ram_143__4
+ QB=#dummy[532] D=nx11613 CLK=clk R=rst
Xix11614 mux21_ni $PINS Y=nx11613 A0=nx35438 A1=camera_module_cache_ram_143__4
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__4 dffr $PINS Q=camera_module_cache_ram_159__4
+ QB=#dummy[533] D=nx11603 CLK=clk R=rst
Xix11604 mux21_ni $PINS Y=nx11603 A0=nx35438 A1=camera_module_cache_ram_159__4
+ S0=nx36764
Xix26328 aoi22 $PINS Y=nx26327 A0=camera_module_cache_ram_191__4 A1=nx36218
+ B0=camera_module_cache_ram_175__4 B1=nx36258
Xcamera_module_cache_reg_ram_191__4 dffr $PINS Q=camera_module_cache_ram_191__4
+ QB=#dummy[534] D=nx11583 CLK=clk R=rst
Xix11584 mux21_ni $PINS Y=nx11583 A0=nx35438 A1=camera_module_cache_ram_191__4
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__4 dffr $PINS Q=camera_module_cache_ram_175__4
+ QB=#dummy[535] D=nx11593 CLK=clk R=rst
Xix11594 mux21_ni $PINS Y=nx11593 A0=nx35438 A1=camera_module_cache_ram_175__4
+ S0=nx36772
Xix26340 aoi22 $PINS Y=nx26339 A0=camera_module_cache_ram_207__4 A1=nx36298
+ B0=camera_module_cache_ram_223__4 B1=nx36338
Xcamera_module_cache_reg_ram_207__4 dffr $PINS Q=camera_module_cache_ram_207__4
+ QB=#dummy[536] D=nx11573 CLK=clk R=rst
Xix11574 mux21_ni $PINS Y=nx11573 A0=nx35440 A1=camera_module_cache_ram_207__4
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__4 dffr $PINS Q=camera_module_cache_ram_223__4
+ QB=#dummy[537] D=nx11563 CLK=clk R=rst
Xix11564 mux21_ni $PINS Y=nx11563 A0=nx35440 A1=camera_module_cache_ram_223__4
+ S0=nx36780
Xix26350 aoi22 $PINS Y=nx26349 A0=camera_module_cache_ram_239__4 A1=nx36378
+ B0=camera_module_cache_ram_255__4 B1=nx36418
Xcamera_module_cache_reg_ram_239__4 dffr $PINS Q=camera_module_cache_ram_239__4
+ QB=#dummy[538] D=nx11553 CLK=clk R=rst
Xix11554 mux21_ni $PINS Y=nx11553 A0=nx35440 A1=camera_module_cache_ram_239__4
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__4 dffr $PINS Q=camera_module_cache_ram_255__4
+ QB=#dummy[539] D=nx11543 CLK=clk R=rst
Xix11544 mux21_ni $PINS Y=nx11543 A0=nx35440 A1=camera_module_cache_ram_255__4
+ S0=nx36788
Xix14303 oai22 $PINS Y=nx14302 A0=nx26363 A1=nx29959 B0=nx31098 B1=nx14278
Xix26364 aoi22 $PINS Y=nx26363 A0=camera_module_algo_module_pixel_value_2
+ A1=nx26370 B0=nx8754 B1=nx11520
Xcamera_module_algo_module_pixel_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_pixel_value_2 QB=#dummy[540] D=nx8963 CLK=clk
Xix8964 mux21_ni $PINS Y=nx8963 A0=nx11512
+ A1=camera_module_algo_module_pixel_value_2 S0=nx37152
Xix26371 mux21_ni $PINS Y=nx26370 A0=nx26372 A1=nx35674 S0=nx36792
Xix26373 nor04 $PINS Y=nx26372 A0=nx11492 A1=nx10838 A2=nx10182 A3=nx9528
Xix11493 nand04 $PINS Y=nx11492 A0=nx26375 A1=nx26521 A2=nx26600 A3=nx26680
Xix26376 oai21 $PINS Y=nx26375 A0=nx11482 A1=nx11404 B0=nx36448
Xix11483 nand04 $PINS Y=nx11482 A0=nx26379 A1=nx26444 A2=nx26453 A3=nx26463
Xix26380 aoi22 $PINS Y=nx26379 A0=camera_module_cache_ram_0__2 A1=nx35818
+ B0=camera_module_cache_ram_16__2 B1=nx35858
Xcamera_module_cache_reg_ram_0__2 dffr $PINS Q=camera_module_cache_ram_0__2
+ QB=#dummy[541] D=nx8953 CLK=clk R=rst
Xix8954 mux21_ni $PINS Y=nx8953 A0=camera_module_cache_ram_0__2 A1=nx35216
+ S0=nx35134
Xix8875 oai221 $PINS Y=nx8874 A0=nx34074 A1=nx26385 B0=nx26411 B1=nx35712
+ C0=nx26415
Xnvm_module_tri_dataout_122 tri01 $PINS Y=nvm_data_122 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_114 tri01 $PINS Y=nvm_data_114 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_106 tri01 $PINS Y=nvm_data_106 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_98 tri01 $PINS Y=nvm_data_98 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_90 tri01 $PINS Y=nvm_data_90 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_82 tri01 $PINS Y=nvm_data_82 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_74 tri01 $PINS Y=nvm_data_74 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_66 tri01 $PINS Y=nvm_data_66 A=nx22549
+ E=nvm_module_GND0
Xix26412 inv01 $PINS Y=nx26411 A=nvm_data_2
Xnvm_module_tri_dataout_2 tri01 $PINS Y=nvm_data_2 A=nx22549 E=nvm_module_GND0
Xix26416 nand02 $PINS Y=nx26415 A0=nx34074 A1=nx8808
Xnvm_module_tri_dataout_58 tri01 $PINS Y=nvm_data_58 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_50 tri01 $PINS Y=nvm_data_50 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_42 tri01 $PINS Y=nvm_data_42 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_34 tri01 $PINS Y=nvm_data_34 A=nx22549
+ E=nvm_module_GND0
Xix8777 oai22 $PINS Y=nx8776 A0=nx34102 A1=nx26429 B0=nx34084 B1=nx26435
Xnvm_module_tri_dataout_26 tri01 $PINS Y=nvm_data_26 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_18 tri01 $PINS Y=nvm_data_18 A=nx22549
+ E=nvm_module_GND0
Xix26436 nand02 $PINS Y=nx26435 A0=nvm_data_10 A1=nx34102
Xnvm_module_tri_dataout_10 tri01 $PINS Y=nvm_data_10 A=nx22549
+ E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__2 dffr $PINS Q=camera_module_cache_ram_16__2
+ QB=#dummy[542] D=nx8943 CLK=clk R=rst
Xix8944 mux21_ni $PINS Y=nx8943 A0=camera_module_cache_ram_16__2 A1=nx35216
+ S0=nx35130
Xix26445 aoi22 $PINS Y=nx26444 A0=camera_module_cache_ram_32__2 A1=nx35898
+ B0=camera_module_cache_ram_48__2 B1=nx35938
Xcamera_module_cache_reg_ram_32__2 dffr $PINS Q=camera_module_cache_ram_32__2
+ QB=#dummy[543] D=nx8933 CLK=clk R=rst
Xix8934 mux21_ni $PINS Y=nx8933 A0=camera_module_cache_ram_32__2 A1=nx35216
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__2 dffr $PINS Q=camera_module_cache_ram_48__2
+ QB=#dummy[544] D=nx8923 CLK=clk R=rst
Xix8924 mux21_ni $PINS Y=nx8923 A0=camera_module_cache_ram_48__2 A1=nx35216
+ S0=nx35122
Xix26454 aoi22 $PINS Y=nx26453 A0=camera_module_cache_ram_64__2 A1=nx35978
+ B0=camera_module_cache_ram_80__2 B1=nx36018
Xcamera_module_cache_reg_ram_64__2 dffr $PINS Q=camera_module_cache_ram_64__2
+ QB=#dummy[545] D=nx8913 CLK=clk R=rst
Xix8914 mux21_ni $PINS Y=nx8913 A0=camera_module_cache_ram_64__2 A1=nx35216
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__2 dffr $PINS Q=camera_module_cache_ram_80__2
+ QB=#dummy[546] D=nx8903 CLK=clk R=rst
Xix8904 mux21_ni $PINS Y=nx8903 A0=camera_module_cache_ram_80__2 A1=nx35216
+ S0=nx35114
Xix26464 aoi22 $PINS Y=nx26463 A0=camera_module_cache_ram_112__2 A1=nx36058
+ B0=camera_module_cache_ram_96__2 B1=nx36098
Xcamera_module_cache_reg_ram_112__2 dffr $PINS Q=camera_module_cache_ram_112__2
+ QB=#dummy[547] D=nx8883 CLK=clk R=rst
Xix8884 mux21_ni $PINS Y=nx8883 A0=camera_module_cache_ram_112__2 A1=nx35216
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__2 dffr $PINS Q=camera_module_cache_ram_96__2
+ QB=#dummy[548] D=nx8893 CLK=clk R=rst
Xix8894 mux21_ni $PINS Y=nx8893 A0=camera_module_cache_ram_96__2 A1=nx35218
+ S0=nx35110
Xix11405 nand04 $PINS Y=nx11404 A0=nx26475 A1=nx26487 A2=nx26497 A3=nx26508
Xix26476 aoi22 $PINS Y=nx26475 A0=camera_module_cache_ram_128__2 A1=nx36138
+ B0=camera_module_cache_ram_144__2 B1=nx36178
Xcamera_module_cache_reg_ram_128__2 dffr $PINS Q=camera_module_cache_ram_128__2
+ QB=#dummy[549] D=nx8873 CLK=clk R=rst
Xix8874 mux21_ni $PINS Y=nx8873 A0=camera_module_cache_ram_128__2 A1=nx35218
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__2 dffr $PINS Q=camera_module_cache_ram_144__2
+ QB=#dummy[550] D=nx8863 CLK=clk R=rst
Xix8864 mux21_ni $PINS Y=nx8863 A0=camera_module_cache_ram_144__2 A1=nx35218
+ S0=nx35098
Xix26488 aoi22 $PINS Y=nx26487 A0=camera_module_cache_ram_176__2 A1=nx36218
+ B0=camera_module_cache_ram_160__2 B1=nx36258
Xcamera_module_cache_reg_ram_176__2 dffr $PINS Q=camera_module_cache_ram_176__2
+ QB=#dummy[551] D=nx8843 CLK=clk R=rst
Xix8844 mux21_ni $PINS Y=nx8843 A0=camera_module_cache_ram_176__2 A1=nx35218
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__2 dffr $PINS Q=camera_module_cache_ram_160__2
+ QB=#dummy[552] D=nx8853 CLK=clk R=rst
Xix8854 mux21_ni $PINS Y=nx8853 A0=camera_module_cache_ram_160__2 A1=nx35218
+ S0=nx35094
Xix26498 aoi22 $PINS Y=nx26497 A0=camera_module_cache_ram_192__2 A1=nx36298
+ B0=camera_module_cache_ram_208__2 B1=nx36338
Xcamera_module_cache_reg_ram_192__2 dffr $PINS Q=camera_module_cache_ram_192__2
+ QB=#dummy[553] D=nx8833 CLK=clk R=rst
Xix8834 mux21_ni $PINS Y=nx8833 A0=camera_module_cache_ram_192__2 A1=nx35218
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__2 dffr $PINS Q=camera_module_cache_ram_208__2
+ QB=#dummy[554] D=nx8823 CLK=clk R=rst
Xix8824 mux21_ni $PINS Y=nx8823 A0=camera_module_cache_ram_208__2 A1=nx35218
+ S0=nx35082
Xix26510 aoi22 $PINS Y=nx26508 A0=camera_module_cache_ram_224__2 A1=nx36378
+ B0=camera_module_cache_ram_240__2 B1=nx36418
Xcamera_module_cache_reg_ram_224__2 dffr $PINS Q=camera_module_cache_ram_224__2
+ QB=#dummy[555] D=nx8813 CLK=clk R=rst
Xix8814 mux21_ni $PINS Y=nx8813 A0=camera_module_cache_ram_224__2 A1=nx35220
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__2 dffr $PINS Q=camera_module_cache_ram_240__2
+ QB=#dummy[556] D=nx8803 CLK=clk R=rst
Xix8804 mux21_ni $PINS Y=nx8803 A0=camera_module_cache_ram_240__2 A1=nx35220
+ S0=nx35074
Xix26522 oai21 $PINS Y=nx26521 A0=nx11320 A1=nx11242 B0=nx36452
Xix11321 nand04 $PINS Y=nx11320 A0=nx26525 A1=nx26536 A2=nx26545 A3=nx26554
Xix26526 aoi22 $PINS Y=nx26525 A0=camera_module_cache_ram_1__2 A1=nx35818
+ B0=camera_module_cache_ram_17__2 B1=nx35858
Xcamera_module_cache_reg_ram_1__2 dffr $PINS Q=camera_module_cache_ram_1__2
+ QB=#dummy[557] D=nx8793 CLK=clk R=rst
Xix8794 mux21_ni $PINS Y=nx8793 A0=camera_module_cache_ram_1__2 A1=nx35220
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__2 dffr $PINS Q=camera_module_cache_ram_17__2
+ QB=#dummy[558] D=nx8783 CLK=clk R=rst
Xix8784 mux21_ni $PINS Y=nx8783 A0=camera_module_cache_ram_17__2 A1=nx35220
+ S0=nx35060
Xix26537 aoi22 $PINS Y=nx26536 A0=camera_module_cache_ram_33__2 A1=nx35898
+ B0=camera_module_cache_ram_49__2 B1=nx35938
Xcamera_module_cache_reg_ram_33__2 dffr $PINS Q=camera_module_cache_ram_33__2
+ QB=#dummy[559] D=nx8773 CLK=clk R=rst
Xix8774 mux21_ni $PINS Y=nx8773 A0=camera_module_cache_ram_33__2 A1=nx35220
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__2 dffr $PINS Q=camera_module_cache_ram_49__2
+ QB=#dummy[560] D=nx8763 CLK=clk R=rst
Xix8764 mux21_ni $PINS Y=nx8763 A0=camera_module_cache_ram_49__2 A1=nx35220
+ S0=nx35052
Xix26546 aoi22 $PINS Y=nx26545 A0=camera_module_cache_ram_65__2 A1=nx35978
+ B0=camera_module_cache_ram_81__2 B1=nx36018
Xcamera_module_cache_reg_ram_65__2 dffr $PINS Q=camera_module_cache_ram_65__2
+ QB=#dummy[561] D=nx8753 CLK=clk R=rst
Xix8754 mux21_ni $PINS Y=nx8753 A0=camera_module_cache_ram_65__2 A1=nx35220
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__2 dffr $PINS Q=camera_module_cache_ram_81__2
+ QB=#dummy[562] D=nx8743 CLK=clk R=rst
Xix8744 mux21_ni $PINS Y=nx8743 A0=camera_module_cache_ram_81__2 A1=nx35222
+ S0=nx35044
Xix26555 aoi22 $PINS Y=nx26554 A0=camera_module_cache_ram_113__2 A1=nx36058
+ B0=camera_module_cache_ram_97__2 B1=nx36098
Xcamera_module_cache_reg_ram_113__2 dffr $PINS Q=camera_module_cache_ram_113__2
+ QB=#dummy[563] D=nx8723 CLK=clk R=rst
Xix8724 mux21_ni $PINS Y=nx8723 A0=camera_module_cache_ram_113__2 A1=nx35222
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__2 dffr $PINS Q=camera_module_cache_ram_97__2
+ QB=#dummy[564] D=nx8733 CLK=clk R=rst
Xix8734 mux21_ni $PINS Y=nx8733 A0=camera_module_cache_ram_97__2 A1=nx35222
+ S0=nx35040
Xix11243 nand04 $PINS Y=nx11242 A0=nx26563 A1=nx26573 A2=nx26582 A3=nx26590
Xix26564 aoi22 $PINS Y=nx26563 A0=camera_module_cache_ram_129__2 A1=nx36138
+ B0=camera_module_cache_ram_145__2 B1=nx36178
Xcamera_module_cache_reg_ram_129__2 dffr $PINS Q=camera_module_cache_ram_129__2
+ QB=#dummy[565] D=nx8713 CLK=clk R=rst
Xix8714 mux21_ni $PINS Y=nx8713 A0=camera_module_cache_ram_129__2 A1=nx35222
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__2 dffr $PINS Q=camera_module_cache_ram_145__2
+ QB=#dummy[566] D=nx8703 CLK=clk R=rst
Xix8704 mux21_ni $PINS Y=nx8703 A0=camera_module_cache_ram_145__2 A1=nx35222
+ S0=nx35028
Xix26574 aoi22 $PINS Y=nx26573 A0=camera_module_cache_ram_177__2 A1=nx36218
+ B0=camera_module_cache_ram_161__2 B1=nx36258
Xcamera_module_cache_reg_ram_177__2 dffr $PINS Q=camera_module_cache_ram_177__2
+ QB=#dummy[567] D=nx8683 CLK=clk R=rst
Xix8684 mux21_ni $PINS Y=nx8683 A0=camera_module_cache_ram_177__2 A1=nx35222
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__2 dffr $PINS Q=camera_module_cache_ram_161__2
+ QB=#dummy[568] D=nx8693 CLK=clk R=rst
Xix8694 mux21_ni $PINS Y=nx8693 A0=camera_module_cache_ram_161__2 A1=nx35222
+ S0=nx35024
Xix26583 aoi22 $PINS Y=nx26582 A0=camera_module_cache_ram_193__2 A1=nx36298
+ B0=camera_module_cache_ram_209__2 B1=nx36338
Xcamera_module_cache_reg_ram_193__2 dffr $PINS Q=camera_module_cache_ram_193__2
+ QB=#dummy[569] D=nx8673 CLK=clk R=rst
Xix8674 mux21_ni $PINS Y=nx8673 A0=camera_module_cache_ram_193__2 A1=nx35224
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__2 dffr $PINS Q=camera_module_cache_ram_209__2
+ QB=#dummy[570] D=nx8663 CLK=clk R=rst
Xix8664 mux21_ni $PINS Y=nx8663 A0=camera_module_cache_ram_209__2 A1=nx35224
+ S0=nx35012
Xix26591 aoi22 $PINS Y=nx26590 A0=camera_module_cache_ram_225__2 A1=nx36378
+ B0=camera_module_cache_ram_241__2 B1=nx36418
Xcamera_module_cache_reg_ram_225__2 dffr $PINS Q=camera_module_cache_ram_225__2
+ QB=#dummy[571] D=nx8653 CLK=clk R=rst
Xix8654 mux21_ni $PINS Y=nx8653 A0=camera_module_cache_ram_225__2 A1=nx35224
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__2 dffr $PINS Q=camera_module_cache_ram_241__2
+ QB=#dummy[572] D=nx8643 CLK=clk R=rst
Xix8644 mux21_ni $PINS Y=nx8643 A0=camera_module_cache_ram_241__2 A1=nx35224
+ S0=nx35004
Xix26601 oai21 $PINS Y=nx26600 A0=nx11156 A1=nx11078 B0=nx36456
Xix11157 nand04 $PINS Y=nx11156 A0=nx26603 A1=nx26614 A2=nx26622 A3=nx26632
Xix26604 aoi22 $PINS Y=nx26603 A0=camera_module_cache_ram_2__2 A1=nx35818
+ B0=camera_module_cache_ram_18__2 B1=nx35858
Xcamera_module_cache_reg_ram_2__2 dffr $PINS Q=camera_module_cache_ram_2__2
+ QB=#dummy[573] D=nx8633 CLK=clk R=rst
Xix8634 mux21_ni $PINS Y=nx8633 A0=camera_module_cache_ram_2__2 A1=nx35224
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__2 dffr $PINS Q=camera_module_cache_ram_18__2
+ QB=#dummy[574] D=nx8623 CLK=clk R=rst
Xix8624 mux21_ni $PINS Y=nx8623 A0=camera_module_cache_ram_18__2 A1=nx35224
+ S0=nx34990
Xix26615 aoi22 $PINS Y=nx26614 A0=camera_module_cache_ram_34__2 A1=nx35898
+ B0=camera_module_cache_ram_50__2 B1=nx35938
Xcamera_module_cache_reg_ram_34__2 dffr $PINS Q=camera_module_cache_ram_34__2
+ QB=#dummy[575] D=nx8613 CLK=clk R=rst
Xix8614 mux21_ni $PINS Y=nx8613 A0=camera_module_cache_ram_34__2 A1=nx35224
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__2 dffr $PINS Q=camera_module_cache_ram_50__2
+ QB=#dummy[576] D=nx8603 CLK=clk R=rst
Xix8604 mux21_ni $PINS Y=nx8603 A0=camera_module_cache_ram_50__2 A1=nx35226
+ S0=nx34982
Xix26623 aoi22 $PINS Y=nx26622 A0=camera_module_cache_ram_66__2 A1=nx35978
+ B0=camera_module_cache_ram_82__2 B1=nx36018
Xcamera_module_cache_reg_ram_66__2 dffr $PINS Q=camera_module_cache_ram_66__2
+ QB=#dummy[577] D=nx8593 CLK=clk R=rst
Xix8594 mux21_ni $PINS Y=nx8593 A0=camera_module_cache_ram_66__2 A1=nx35226
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__2 dffr $PINS Q=camera_module_cache_ram_82__2
+ QB=#dummy[578] D=nx8583 CLK=clk R=rst
Xix8584 mux21_ni $PINS Y=nx8583 A0=camera_module_cache_ram_82__2 A1=nx35226
+ S0=nx34974
Xix26633 aoi22 $PINS Y=nx26632 A0=camera_module_cache_ram_114__2 A1=nx36058
+ B0=camera_module_cache_ram_98__2 B1=nx36098
Xcamera_module_cache_reg_ram_114__2 dffr $PINS Q=camera_module_cache_ram_114__2
+ QB=#dummy[579] D=nx8563 CLK=clk R=rst
Xix8564 mux21_ni $PINS Y=nx8563 A0=camera_module_cache_ram_114__2 A1=nx35226
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__2 dffr $PINS Q=camera_module_cache_ram_98__2
+ QB=#dummy[580] D=nx8573 CLK=clk R=rst
Xix8574 mux21_ni $PINS Y=nx8573 A0=camera_module_cache_ram_98__2 A1=nx35226
+ S0=nx34970
Xix11079 nand04 $PINS Y=nx11078 A0=nx26643 A1=nx26653 A2=nx26662 A3=nx26670
Xix26644 aoi22 $PINS Y=nx26643 A0=camera_module_cache_ram_130__2 A1=nx36138
+ B0=camera_module_cache_ram_146__2 B1=nx36178
Xcamera_module_cache_reg_ram_130__2 dffr $PINS Q=camera_module_cache_ram_130__2
+ QB=#dummy[581] D=nx8553 CLK=clk R=rst
Xix8554 mux21_ni $PINS Y=nx8553 A0=camera_module_cache_ram_130__2 A1=nx35226
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__2 dffr $PINS Q=camera_module_cache_ram_146__2
+ QB=#dummy[582] D=nx8543 CLK=clk R=rst
Xix8544 mux21_ni $PINS Y=nx8543 A0=camera_module_cache_ram_146__2 A1=nx35226
+ S0=nx34958
Xix26654 aoi22 $PINS Y=nx26653 A0=camera_module_cache_ram_178__2 A1=nx36218
+ B0=camera_module_cache_ram_162__2 B1=nx36258
Xcamera_module_cache_reg_ram_178__2 dffr $PINS Q=camera_module_cache_ram_178__2
+ QB=#dummy[583] D=nx8523 CLK=clk R=rst
Xix8524 mux21_ni $PINS Y=nx8523 A0=camera_module_cache_ram_178__2 A1=nx35228
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__2 dffr $PINS Q=camera_module_cache_ram_162__2
+ QB=#dummy[584] D=nx8533 CLK=clk R=rst
Xix8534 mux21_ni $PINS Y=nx8533 A0=camera_module_cache_ram_162__2 A1=nx35228
+ S0=nx34954
Xix26663 aoi22 $PINS Y=nx26662 A0=camera_module_cache_ram_194__2 A1=nx36298
+ B0=camera_module_cache_ram_210__2 B1=nx36338
Xcamera_module_cache_reg_ram_194__2 dffr $PINS Q=camera_module_cache_ram_194__2
+ QB=#dummy[585] D=nx8513 CLK=clk R=rst
Xix8514 mux21_ni $PINS Y=nx8513 A0=camera_module_cache_ram_194__2 A1=nx35228
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__2 dffr $PINS Q=camera_module_cache_ram_210__2
+ QB=#dummy[586] D=nx8503 CLK=clk R=rst
Xix8504 mux21_ni $PINS Y=nx8503 A0=camera_module_cache_ram_210__2 A1=nx35228
+ S0=nx34942
Xix26671 aoi22 $PINS Y=nx26670 A0=camera_module_cache_ram_226__2 A1=nx36378
+ B0=camera_module_cache_ram_242__2 B1=nx36418
Xcamera_module_cache_reg_ram_226__2 dffr $PINS Q=camera_module_cache_ram_226__2
+ QB=#dummy[587] D=nx8493 CLK=clk R=rst
Xix8494 mux21_ni $PINS Y=nx8493 A0=camera_module_cache_ram_226__2 A1=nx35228
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__2 dffr $PINS Q=camera_module_cache_ram_242__2
+ QB=#dummy[588] D=nx8483 CLK=clk R=rst
Xix8484 mux21_ni $PINS Y=nx8483 A0=camera_module_cache_ram_242__2 A1=nx35228
+ S0=nx34934
Xix26681 oai21 $PINS Y=nx26680 A0=nx10994 A1=nx10916 B0=nx36460
Xix10995 nand04 $PINS Y=nx10994 A0=nx26683 A1=nx26694 A2=nx26702 A3=nx26712
Xix26684 aoi22 $PINS Y=nx26683 A0=camera_module_cache_ram_3__2 A1=nx35818
+ B0=camera_module_cache_ram_19__2 B1=nx35858
Xcamera_module_cache_reg_ram_3__2 dffr $PINS Q=camera_module_cache_ram_3__2
+ QB=#dummy[589] D=nx8473 CLK=clk R=rst
Xix8474 mux21_ni $PINS Y=nx8473 A0=camera_module_cache_ram_3__2 A1=nx35228
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__2 dffr $PINS Q=camera_module_cache_ram_19__2
+ QB=#dummy[590] D=nx8463 CLK=clk R=rst
Xix8464 mux21_ni $PINS Y=nx8463 A0=camera_module_cache_ram_19__2 A1=nx35230
+ S0=nx34920
Xix26695 aoi22 $PINS Y=nx26694 A0=camera_module_cache_ram_35__2 A1=nx35898
+ B0=camera_module_cache_ram_51__2 B1=nx35938
Xcamera_module_cache_reg_ram_35__2 dffr $PINS Q=camera_module_cache_ram_35__2
+ QB=#dummy[591] D=nx8453 CLK=clk R=rst
Xix8454 mux21_ni $PINS Y=nx8453 A0=camera_module_cache_ram_35__2 A1=nx35230
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__2 dffr $PINS Q=camera_module_cache_ram_51__2
+ QB=#dummy[592] D=nx8443 CLK=clk R=rst
Xix8444 mux21_ni $PINS Y=nx8443 A0=camera_module_cache_ram_51__2 A1=nx35230
+ S0=nx34912
Xix26703 aoi22 $PINS Y=nx26702 A0=camera_module_cache_ram_67__2 A1=nx35978
+ B0=camera_module_cache_ram_83__2 B1=nx36018
Xcamera_module_cache_reg_ram_67__2 dffr $PINS Q=camera_module_cache_ram_67__2
+ QB=#dummy[593] D=nx8433 CLK=clk R=rst
Xix8434 mux21_ni $PINS Y=nx8433 A0=camera_module_cache_ram_67__2 A1=nx35230
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__2 dffr $PINS Q=camera_module_cache_ram_83__2
+ QB=#dummy[594] D=nx8423 CLK=clk R=rst
Xix8424 mux21_ni $PINS Y=nx8423 A0=camera_module_cache_ram_83__2 A1=nx35230
+ S0=nx34904
Xix26713 aoi22 $PINS Y=nx26712 A0=camera_module_cache_ram_115__2 A1=nx36058
+ B0=camera_module_cache_ram_99__2 B1=nx36098
Xcamera_module_cache_reg_ram_115__2 dffr $PINS Q=camera_module_cache_ram_115__2
+ QB=#dummy[595] D=nx8403 CLK=clk R=rst
Xix8404 mux21_ni $PINS Y=nx8403 A0=camera_module_cache_ram_115__2 A1=nx35230
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__2 dffr $PINS Q=camera_module_cache_ram_99__2
+ QB=#dummy[596] D=nx8413 CLK=clk R=rst
Xix8414 mux21_ni $PINS Y=nx8413 A0=camera_module_cache_ram_99__2 A1=nx35230
+ S0=nx34900
Xix10917 nand04 $PINS Y=nx10916 A0=nx26723 A1=nx26733 A2=nx26742 A3=nx26750
Xix26724 aoi22 $PINS Y=nx26723 A0=camera_module_cache_ram_131__2 A1=nx36138
+ B0=camera_module_cache_ram_147__2 B1=nx36178
Xcamera_module_cache_reg_ram_131__2 dffr $PINS Q=camera_module_cache_ram_131__2
+ QB=#dummy[597] D=nx8393 CLK=clk R=rst
Xix8394 mux21_ni $PINS Y=nx8393 A0=camera_module_cache_ram_131__2 A1=nx35232
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__2 dffr $PINS Q=camera_module_cache_ram_147__2
+ QB=#dummy[598] D=nx8383 CLK=clk R=rst
Xix8384 mux21_ni $PINS Y=nx8383 A0=camera_module_cache_ram_147__2 A1=nx35232
+ S0=nx34888
Xix26734 aoi22 $PINS Y=nx26733 A0=camera_module_cache_ram_179__2 A1=nx36218
+ B0=camera_module_cache_ram_163__2 B1=nx36258
Xcamera_module_cache_reg_ram_179__2 dffr $PINS Q=camera_module_cache_ram_179__2
+ QB=#dummy[599] D=nx8363 CLK=clk R=rst
Xix8364 mux21_ni $PINS Y=nx8363 A0=camera_module_cache_ram_179__2 A1=nx35232
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__2 dffr $PINS Q=camera_module_cache_ram_163__2
+ QB=#dummy[600] D=nx8373 CLK=clk R=rst
Xix8374 mux21_ni $PINS Y=nx8373 A0=camera_module_cache_ram_163__2 A1=nx35232
+ S0=nx34884
Xix26743 aoi22 $PINS Y=nx26742 A0=camera_module_cache_ram_195__2 A1=nx36298
+ B0=camera_module_cache_ram_211__2 B1=nx36338
Xcamera_module_cache_reg_ram_195__2 dffr $PINS Q=camera_module_cache_ram_195__2
+ QB=#dummy[601] D=nx8353 CLK=clk R=rst
Xix8354 mux21_ni $PINS Y=nx8353 A0=camera_module_cache_ram_195__2 A1=nx35232
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__2 dffr $PINS Q=camera_module_cache_ram_211__2
+ QB=#dummy[602] D=nx8343 CLK=clk R=rst
Xix8344 mux21_ni $PINS Y=nx8343 A0=camera_module_cache_ram_211__2 A1=nx35232
+ S0=nx34872
Xix26751 aoi22 $PINS Y=nx26750 A0=camera_module_cache_ram_227__2 A1=nx36378
+ B0=camera_module_cache_ram_243__2 B1=nx36418
Xcamera_module_cache_reg_ram_227__2 dffr $PINS Q=camera_module_cache_ram_227__2
+ QB=#dummy[603] D=nx8333 CLK=clk R=rst
Xix8334 mux21_ni $PINS Y=nx8333 A0=camera_module_cache_ram_227__2 A1=nx35232
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__2 dffr $PINS Q=camera_module_cache_ram_243__2
+ QB=#dummy[604] D=nx8323 CLK=clk R=rst
Xix8324 mux21_ni $PINS Y=nx8323 A0=camera_module_cache_ram_243__2 A1=nx35234
+ S0=nx34864
Xix10839 nand04 $PINS Y=nx10838 A0=nx26761 A1=nx26843 A2=nx26943 A3=nx27032
Xix26762 oai21 $PINS Y=nx26761 A0=nx10828 A1=nx10750 B0=nx36464
Xix10829 nand04 $PINS Y=nx10828 A0=nx26765 A1=nx26774 A2=nx26782 A3=nx26792
Xix26766 aoi22 $PINS Y=nx26765 A0=camera_module_cache_ram_4__2 A1=nx35818
+ B0=camera_module_cache_ram_20__2 B1=nx35858
Xcamera_module_cache_reg_ram_4__2 dffr $PINS Q=camera_module_cache_ram_4__2
+ QB=#dummy[605] D=nx8313 CLK=clk R=rst
Xix8314 mux21_ni $PINS Y=nx8313 A0=camera_module_cache_ram_4__2 A1=nx35234
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__2 dffr $PINS Q=camera_module_cache_ram_20__2
+ QB=#dummy[606] D=nx8303 CLK=clk R=rst
Xix8304 mux21_ni $PINS Y=nx8303 A0=camera_module_cache_ram_20__2 A1=nx35234
+ S0=nx34850
Xix26775 aoi22 $PINS Y=nx26774 A0=camera_module_cache_ram_36__2 A1=nx35898
+ B0=camera_module_cache_ram_52__2 B1=nx35938
Xcamera_module_cache_reg_ram_36__2 dffr $PINS Q=camera_module_cache_ram_36__2
+ QB=#dummy[607] D=nx8293 CLK=clk R=rst
Xix8294 mux21_ni $PINS Y=nx8293 A0=camera_module_cache_ram_36__2 A1=nx35234
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__2 dffr $PINS Q=camera_module_cache_ram_52__2
+ QB=#dummy[608] D=nx8283 CLK=clk R=rst
Xix8284 mux21_ni $PINS Y=nx8283 A0=camera_module_cache_ram_52__2 A1=nx35234
+ S0=nx34842
Xix26783 aoi22 $PINS Y=nx26782 A0=camera_module_cache_ram_68__2 A1=nx35978
+ B0=camera_module_cache_ram_84__2 B1=nx36018
Xcamera_module_cache_reg_ram_68__2 dffr $PINS Q=camera_module_cache_ram_68__2
+ QB=#dummy[609] D=nx8273 CLK=clk R=rst
Xix8274 mux21_ni $PINS Y=nx8273 A0=camera_module_cache_ram_68__2 A1=nx35234
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__2 dffr $PINS Q=camera_module_cache_ram_84__2
+ QB=#dummy[610] D=nx8263 CLK=clk R=rst
Xix8264 mux21_ni $PINS Y=nx8263 A0=camera_module_cache_ram_84__2 A1=nx35234
+ S0=nx34834
Xix26793 aoi22 $PINS Y=nx26792 A0=camera_module_cache_ram_116__2 A1=nx36058
+ B0=camera_module_cache_ram_100__2 B1=nx36098
Xcamera_module_cache_reg_ram_116__2 dffr $PINS Q=camera_module_cache_ram_116__2
+ QB=#dummy[611] D=nx8243 CLK=clk R=rst
Xix8244 mux21_ni $PINS Y=nx8243 A0=camera_module_cache_ram_116__2 A1=nx35236
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__2 dffr $PINS Q=camera_module_cache_ram_100__2
+ QB=#dummy[612] D=nx8253 CLK=clk R=rst
Xix8254 mux21_ni $PINS Y=nx8253 A0=camera_module_cache_ram_100__2 A1=nx35236
+ S0=nx34830
Xix10751 nand04 $PINS Y=nx10750 A0=nx26803 A1=nx26813 A2=nx26822 A3=nx26831
Xix26804 aoi22 $PINS Y=nx26803 A0=camera_module_cache_ram_132__2 A1=nx36138
+ B0=camera_module_cache_ram_148__2 B1=nx36178
Xcamera_module_cache_reg_ram_132__2 dffr $PINS Q=camera_module_cache_ram_132__2
+ QB=#dummy[613] D=nx8233 CLK=clk R=rst
Xix8234 mux21_ni $PINS Y=nx8233 A0=camera_module_cache_ram_132__2 A1=nx35236
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__2 dffr $PINS Q=camera_module_cache_ram_148__2
+ QB=#dummy[614] D=nx8223 CLK=clk R=rst
Xix8224 mux21_ni $PINS Y=nx8223 A0=camera_module_cache_ram_148__2 A1=nx35236
+ S0=nx34818
Xix26814 aoi22 $PINS Y=nx26813 A0=camera_module_cache_ram_180__2 A1=nx36218
+ B0=camera_module_cache_ram_164__2 B1=nx36258
Xcamera_module_cache_reg_ram_180__2 dffr $PINS Q=camera_module_cache_ram_180__2
+ QB=#dummy[615] D=nx8203 CLK=clk R=rst
Xix8204 mux21_ni $PINS Y=nx8203 A0=camera_module_cache_ram_180__2 A1=nx35236
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__2 dffr $PINS Q=camera_module_cache_ram_164__2
+ QB=#dummy[616] D=nx8213 CLK=clk R=rst
Xix8214 mux21_ni $PINS Y=nx8213 A0=camera_module_cache_ram_164__2 A1=nx35236
+ S0=nx34814
Xix26823 aoi22 $PINS Y=nx26822 A0=camera_module_cache_ram_196__2 A1=nx36298
+ B0=camera_module_cache_ram_212__2 B1=nx36338
Xcamera_module_cache_reg_ram_196__2 dffr $PINS Q=camera_module_cache_ram_196__2
+ QB=#dummy[617] D=nx8193 CLK=clk R=rst
Xix8194 mux21_ni $PINS Y=nx8193 A0=camera_module_cache_ram_196__2 A1=nx35236
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__2 dffr $PINS Q=camera_module_cache_ram_212__2
+ QB=#dummy[618] D=nx8183 CLK=clk R=rst
Xix8184 mux21_ni $PINS Y=nx8183 A0=camera_module_cache_ram_212__2 A1=nx35238
+ S0=nx34802
Xix26832 aoi22 $PINS Y=nx26831 A0=camera_module_cache_ram_228__2 A1=nx36378
+ B0=camera_module_cache_ram_244__2 B1=nx36418
Xcamera_module_cache_reg_ram_228__2 dffr $PINS Q=camera_module_cache_ram_228__2
+ QB=#dummy[619] D=nx8173 CLK=clk R=rst
Xix8174 mux21_ni $PINS Y=nx8173 A0=camera_module_cache_ram_228__2 A1=nx35238
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__2 dffr $PINS Q=camera_module_cache_ram_244__2
+ QB=#dummy[620] D=nx8163 CLK=clk R=rst
Xix8164 mux21_ni $PINS Y=nx8163 A0=camera_module_cache_ram_244__2 A1=nx35238
+ S0=nx34794
Xix26844 oai21 $PINS Y=nx26843 A0=nx10666 A1=nx10588 B0=nx36468
Xix10667 nand04 $PINS Y=nx10666 A0=nx26847 A1=nx26859 A2=nx26871 A3=nx26883
Xix26848 aoi22 $PINS Y=nx26847 A0=camera_module_cache_ram_5__2 A1=nx35818
+ B0=camera_module_cache_ram_21__2 B1=nx35858
Xcamera_module_cache_reg_ram_5__2 dffr $PINS Q=camera_module_cache_ram_5__2
+ QB=#dummy[621] D=nx8153 CLK=clk R=rst
Xix8154 mux21_ni $PINS Y=nx8153 A0=camera_module_cache_ram_5__2 A1=nx35238
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__2 dffr $PINS Q=camera_module_cache_ram_21__2
+ QB=#dummy[622] D=nx8143 CLK=clk R=rst
Xix8144 mux21_ni $PINS Y=nx8143 A0=camera_module_cache_ram_21__2 A1=nx35238
+ S0=nx34780
Xix26860 aoi22 $PINS Y=nx26859 A0=camera_module_cache_ram_37__2 A1=nx35898
+ B0=camera_module_cache_ram_53__2 B1=nx35938
Xcamera_module_cache_reg_ram_37__2 dffr $PINS Q=camera_module_cache_ram_37__2
+ QB=#dummy[623] D=nx8133 CLK=clk R=rst
Xix8134 mux21_ni $PINS Y=nx8133 A0=camera_module_cache_ram_37__2 A1=nx35238
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__2 dffr $PINS Q=camera_module_cache_ram_53__2
+ QB=#dummy[624] D=nx8123 CLK=clk R=rst
Xix8124 mux21_ni $PINS Y=nx8123 A0=camera_module_cache_ram_53__2 A1=nx35238
+ S0=nx34772
Xix26872 aoi22 $PINS Y=nx26871 A0=camera_module_cache_ram_69__2 A1=nx35978
+ B0=camera_module_cache_ram_85__2 B1=nx36018
Xcamera_module_cache_reg_ram_69__2 dffr $PINS Q=camera_module_cache_ram_69__2
+ QB=#dummy[625] D=nx8113 CLK=clk R=rst
Xix8114 mux21_ni $PINS Y=nx8113 A0=camera_module_cache_ram_69__2 A1=nx35240
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__2 dffr $PINS Q=camera_module_cache_ram_85__2
+ QB=#dummy[626] D=nx8103 CLK=clk R=rst
Xix8104 mux21_ni $PINS Y=nx8103 A0=camera_module_cache_ram_85__2 A1=nx35240
+ S0=nx34764
Xix26884 aoi22 $PINS Y=nx26883 A0=camera_module_cache_ram_117__2 A1=nx36058
+ B0=camera_module_cache_ram_101__2 B1=nx36098
Xcamera_module_cache_reg_ram_117__2 dffr $PINS Q=camera_module_cache_ram_117__2
+ QB=#dummy[627] D=nx8083 CLK=clk R=rst
Xix8084 mux21_ni $PINS Y=nx8083 A0=camera_module_cache_ram_117__2 A1=nx35240
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__2 dffr $PINS Q=camera_module_cache_ram_101__2
+ QB=#dummy[628] D=nx8093 CLK=clk R=rst
Xix8094 mux21_ni $PINS Y=nx8093 A0=camera_module_cache_ram_101__2 A1=nx35240
+ S0=nx34760
Xix10589 nand04 $PINS Y=nx10588 A0=nx26895 A1=nx26907 A2=nx26919 A3=nx26931
Xix26896 aoi22 $PINS Y=nx26895 A0=camera_module_cache_ram_133__2 A1=nx36138
+ B0=camera_module_cache_ram_149__2 B1=nx36178
Xcamera_module_cache_reg_ram_133__2 dffr $PINS Q=camera_module_cache_ram_133__2
+ QB=#dummy[629] D=nx8073 CLK=clk R=rst
Xix8074 mux21_ni $PINS Y=nx8073 A0=camera_module_cache_ram_133__2 A1=nx35240
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__2 dffr $PINS Q=camera_module_cache_ram_149__2
+ QB=#dummy[630] D=nx8063 CLK=clk R=rst
Xix8064 mux21_ni $PINS Y=nx8063 A0=camera_module_cache_ram_149__2 A1=nx35240
+ S0=nx34748
Xix26908 aoi22 $PINS Y=nx26907 A0=camera_module_cache_ram_181__2 A1=nx36218
+ B0=camera_module_cache_ram_165__2 B1=nx36258
Xcamera_module_cache_reg_ram_181__2 dffr $PINS Q=camera_module_cache_ram_181__2
+ QB=#dummy[631] D=nx8043 CLK=clk R=rst
Xix8044 mux21_ni $PINS Y=nx8043 A0=camera_module_cache_ram_181__2 A1=nx35240
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__2 dffr $PINS Q=camera_module_cache_ram_165__2
+ QB=#dummy[632] D=nx8053 CLK=clk R=rst
Xix8054 mux21_ni $PINS Y=nx8053 A0=camera_module_cache_ram_165__2 A1=nx35242
+ S0=nx34744
Xix26920 aoi22 $PINS Y=nx26919 A0=camera_module_cache_ram_197__2 A1=nx36298
+ B0=camera_module_cache_ram_213__2 B1=nx36338
Xcamera_module_cache_reg_ram_197__2 dffr $PINS Q=camera_module_cache_ram_197__2
+ QB=#dummy[633] D=nx8033 CLK=clk R=rst
Xix8034 mux21_ni $PINS Y=nx8033 A0=camera_module_cache_ram_197__2 A1=nx35242
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__2 dffr $PINS Q=camera_module_cache_ram_213__2
+ QB=#dummy[634] D=nx8023 CLK=clk R=rst
Xix8024 mux21_ni $PINS Y=nx8023 A0=camera_module_cache_ram_213__2 A1=nx35242
+ S0=nx34732
Xix26932 aoi22 $PINS Y=nx26931 A0=camera_module_cache_ram_229__2 A1=nx36378
+ B0=camera_module_cache_ram_245__2 B1=nx36418
Xcamera_module_cache_reg_ram_229__2 dffr $PINS Q=camera_module_cache_ram_229__2
+ QB=#dummy[635] D=nx8013 CLK=clk R=rst
Xix8014 mux21_ni $PINS Y=nx8013 A0=camera_module_cache_ram_229__2 A1=nx35242
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__2 dffr $PINS Q=camera_module_cache_ram_245__2
+ QB=#dummy[636] D=nx8003 CLK=clk R=rst
Xix8004 mux21_ni $PINS Y=nx8003 A0=camera_module_cache_ram_245__2 A1=nx35242
+ S0=nx34724
Xix26944 oai21 $PINS Y=nx26943 A0=nx10502 A1=nx10424 B0=nx36472
Xix10503 nand04 $PINS Y=nx10502 A0=nx26947 A1=nx26959 A2=nx26971 A3=nx26983
Xix26948 aoi22 $PINS Y=nx26947 A0=camera_module_cache_ram_6__2 A1=nx35820
+ B0=camera_module_cache_ram_22__2 B1=nx35860
Xcamera_module_cache_reg_ram_6__2 dffr $PINS Q=camera_module_cache_ram_6__2
+ QB=#dummy[637] D=nx7993 CLK=clk R=rst
Xix7994 mux21_ni $PINS Y=nx7993 A0=camera_module_cache_ram_6__2 A1=nx35242
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__2 dffr $PINS Q=camera_module_cache_ram_22__2
+ QB=#dummy[638] D=nx7983 CLK=clk R=rst
Xix7984 mux21_ni $PINS Y=nx7983 A0=camera_module_cache_ram_22__2 A1=nx35242
+ S0=nx34710
Xix26960 aoi22 $PINS Y=nx26959 A0=camera_module_cache_ram_38__2 A1=nx35900
+ B0=camera_module_cache_ram_54__2 B1=nx35940
Xcamera_module_cache_reg_ram_38__2 dffr $PINS Q=camera_module_cache_ram_38__2
+ QB=#dummy[639] D=nx7973 CLK=clk R=rst
Xix7974 mux21_ni $PINS Y=nx7973 A0=camera_module_cache_ram_38__2 A1=nx35244
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__2 dffr $PINS Q=camera_module_cache_ram_54__2
+ QB=#dummy[640] D=nx7963 CLK=clk R=rst
Xix7964 mux21_ni $PINS Y=nx7963 A0=camera_module_cache_ram_54__2 A1=nx35244
+ S0=nx34702
Xix26972 aoi22 $PINS Y=nx26971 A0=camera_module_cache_ram_70__2 A1=nx35980
+ B0=camera_module_cache_ram_86__2 B1=nx36020
Xcamera_module_cache_reg_ram_70__2 dffr $PINS Q=camera_module_cache_ram_70__2
+ QB=#dummy[641] D=nx7953 CLK=clk R=rst
Xix7954 mux21_ni $PINS Y=nx7953 A0=camera_module_cache_ram_70__2 A1=nx35244
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__2 dffr $PINS Q=camera_module_cache_ram_86__2
+ QB=#dummy[642] D=nx7943 CLK=clk R=rst
Xix7944 mux21_ni $PINS Y=nx7943 A0=camera_module_cache_ram_86__2 A1=nx35244
+ S0=nx34694
Xix26984 aoi22 $PINS Y=nx26983 A0=camera_module_cache_ram_118__2 A1=nx36060
+ B0=camera_module_cache_ram_102__2 B1=nx36100
Xcamera_module_cache_reg_ram_118__2 dffr $PINS Q=camera_module_cache_ram_118__2
+ QB=#dummy[643] D=nx7923 CLK=clk R=rst
Xix7924 mux21_ni $PINS Y=nx7923 A0=camera_module_cache_ram_118__2 A1=nx35244
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__2 dffr $PINS Q=camera_module_cache_ram_102__2
+ QB=#dummy[644] D=nx7933 CLK=clk R=rst
Xix7934 mux21_ni $PINS Y=nx7933 A0=camera_module_cache_ram_102__2 A1=nx35244
+ S0=nx34690
Xix10425 nand04 $PINS Y=nx10424 A0=nx26993 A1=nx27004 A2=nx27013 A3=nx27023
Xix26994 aoi22 $PINS Y=nx26993 A0=camera_module_cache_ram_134__2 A1=nx36140
+ B0=camera_module_cache_ram_150__2 B1=nx36180
Xcamera_module_cache_reg_ram_134__2 dffr $PINS Q=camera_module_cache_ram_134__2
+ QB=#dummy[645] D=nx7913 CLK=clk R=rst
Xix7914 mux21_ni $PINS Y=nx7913 A0=camera_module_cache_ram_134__2 A1=nx35244
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__2 dffr $PINS Q=camera_module_cache_ram_150__2
+ QB=#dummy[646] D=nx7903 CLK=clk R=rst
Xix7904 mux21_ni $PINS Y=nx7903 A0=camera_module_cache_ram_150__2 A1=nx35246
+ S0=nx34678
Xix27005 aoi22 $PINS Y=nx27004 A0=camera_module_cache_ram_182__2 A1=nx36220
+ B0=camera_module_cache_ram_166__2 B1=nx36260
Xcamera_module_cache_reg_ram_182__2 dffr $PINS Q=camera_module_cache_ram_182__2
+ QB=#dummy[647] D=nx7883 CLK=clk R=rst
Xix7884 mux21_ni $PINS Y=nx7883 A0=camera_module_cache_ram_182__2 A1=nx35246
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__2 dffr $PINS Q=camera_module_cache_ram_166__2
+ QB=#dummy[648] D=nx7893 CLK=clk R=rst
Xix7894 mux21_ni $PINS Y=nx7893 A0=camera_module_cache_ram_166__2 A1=nx35246
+ S0=nx34674
Xix27014 aoi22 $PINS Y=nx27013 A0=camera_module_cache_ram_198__2 A1=nx36300
+ B0=camera_module_cache_ram_214__2 B1=nx36340
Xcamera_module_cache_reg_ram_198__2 dffr $PINS Q=camera_module_cache_ram_198__2
+ QB=#dummy[649] D=nx7873 CLK=clk R=rst
Xix7874 mux21_ni $PINS Y=nx7873 A0=camera_module_cache_ram_198__2 A1=nx35246
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__2 dffr $PINS Q=camera_module_cache_ram_214__2
+ QB=#dummy[650] D=nx7863 CLK=clk R=rst
Xix7864 mux21_ni $PINS Y=nx7863 A0=camera_module_cache_ram_214__2 A1=nx35246
+ S0=nx34662
Xix27024 aoi22 $PINS Y=nx27023 A0=camera_module_cache_ram_230__2 A1=nx36380
+ B0=camera_module_cache_ram_246__2 B1=nx36420
Xcamera_module_cache_reg_ram_230__2 dffr $PINS Q=camera_module_cache_ram_230__2
+ QB=#dummy[651] D=nx7853 CLK=clk R=rst
Xix7854 mux21_ni $PINS Y=nx7853 A0=camera_module_cache_ram_230__2 A1=nx35246
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__2 dffr $PINS Q=camera_module_cache_ram_246__2
+ QB=#dummy[652] D=nx7843 CLK=clk R=rst
Xix7844 mux21_ni $PINS Y=nx7843 A0=camera_module_cache_ram_246__2 A1=nx35246
+ S0=nx34654
Xix27033 oai21 $PINS Y=nx27032 A0=nx10340 A1=nx10262 B0=nx36476
Xix10341 nand04 $PINS Y=nx10340 A0=nx27035 A1=nx27045 A2=nx27054 A3=nx27065
Xix27036 aoi22 $PINS Y=nx27035 A0=camera_module_cache_ram_7__2 A1=nx35820
+ B0=camera_module_cache_ram_23__2 B1=nx35860
Xcamera_module_cache_reg_ram_7__2 dffr $PINS Q=camera_module_cache_ram_7__2
+ QB=#dummy[653] D=nx7833 CLK=clk R=rst
Xix7834 mux21_ni $PINS Y=nx7833 A0=camera_module_cache_ram_7__2 A1=nx35248
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__2 dffr $PINS Q=camera_module_cache_ram_23__2
+ QB=#dummy[654] D=nx7823 CLK=clk R=rst
Xix7824 mux21_ni $PINS Y=nx7823 A0=camera_module_cache_ram_23__2 A1=nx35248
+ S0=nx34640
Xix27046 aoi22 $PINS Y=nx27045 A0=camera_module_cache_ram_39__2 A1=nx35900
+ B0=camera_module_cache_ram_55__2 B1=nx35940
Xcamera_module_cache_reg_ram_39__2 dffr $PINS Q=camera_module_cache_ram_39__2
+ QB=#dummy[655] D=nx7813 CLK=clk R=rst
Xix7814 mux21_ni $PINS Y=nx7813 A0=camera_module_cache_ram_39__2 A1=nx35248
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__2 dffr $PINS Q=camera_module_cache_ram_55__2
+ QB=#dummy[656] D=nx7803 CLK=clk R=rst
Xix7804 mux21_ni $PINS Y=nx7803 A0=camera_module_cache_ram_55__2 A1=nx35248
+ S0=nx34632
Xix27055 aoi22 $PINS Y=nx27054 A0=camera_module_cache_ram_71__2 A1=nx35980
+ B0=camera_module_cache_ram_87__2 B1=nx36020
Xcamera_module_cache_reg_ram_71__2 dffr $PINS Q=camera_module_cache_ram_71__2
+ QB=#dummy[657] D=nx7793 CLK=clk R=rst
Xix7794 mux21_ni $PINS Y=nx7793 A0=camera_module_cache_ram_71__2 A1=nx35248
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__2 dffr $PINS Q=camera_module_cache_ram_87__2
+ QB=#dummy[658] D=nx7783 CLK=clk R=rst
Xix7784 mux21_ni $PINS Y=nx7783 A0=camera_module_cache_ram_87__2 A1=nx35248
+ S0=nx34624
Xix27066 aoi22 $PINS Y=nx27065 A0=camera_module_cache_ram_119__2 A1=nx36060
+ B0=camera_module_cache_ram_103__2 B1=nx36100
Xcamera_module_cache_reg_ram_119__2 dffr $PINS Q=camera_module_cache_ram_119__2
+ QB=#dummy[659] D=nx7763 CLK=clk R=rst
Xix7764 mux21_ni $PINS Y=nx7763 A0=camera_module_cache_ram_119__2 A1=nx35248
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__2 dffr $PINS Q=camera_module_cache_ram_103__2
+ QB=#dummy[660] D=nx7773 CLK=clk R=rst
Xix7774 mux21_ni $PINS Y=nx7773 A0=camera_module_cache_ram_103__2 A1=nx35250
+ S0=nx34620
Xix10263 nand04 $PINS Y=nx10262 A0=nx27076 A1=nx27088 A2=nx27097 A3=nx27105
Xix27078 aoi22 $PINS Y=nx27076 A0=camera_module_cache_ram_135__2 A1=nx36140
+ B0=camera_module_cache_ram_151__2 B1=nx36180
Xcamera_module_cache_reg_ram_135__2 dffr $PINS Q=camera_module_cache_ram_135__2
+ QB=#dummy[661] D=nx7753 CLK=clk R=rst
Xix7754 mux21_ni $PINS Y=nx7753 A0=camera_module_cache_ram_135__2 A1=nx35250
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__2 dffr $PINS Q=camera_module_cache_ram_151__2
+ QB=#dummy[662] D=nx7743 CLK=clk R=rst
Xix7744 mux21_ni $PINS Y=nx7743 A0=camera_module_cache_ram_151__2 A1=nx35250
+ S0=nx34608
Xix27089 aoi22 $PINS Y=nx27088 A0=camera_module_cache_ram_183__2 A1=nx36220
+ B0=camera_module_cache_ram_167__2 B1=nx36260
Xcamera_module_cache_reg_ram_183__2 dffr $PINS Q=camera_module_cache_ram_183__2
+ QB=#dummy[663] D=nx7723 CLK=clk R=rst
Xix7724 mux21_ni $PINS Y=nx7723 A0=camera_module_cache_ram_183__2 A1=nx35250
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__2 dffr $PINS Q=camera_module_cache_ram_167__2
+ QB=#dummy[664] D=nx7733 CLK=clk R=rst
Xix7734 mux21_ni $PINS Y=nx7733 A0=camera_module_cache_ram_167__2 A1=nx35250
+ S0=nx34604
Xix27098 aoi22 $PINS Y=nx27097 A0=camera_module_cache_ram_199__2 A1=nx36300
+ B0=camera_module_cache_ram_215__2 B1=nx36340
Xcamera_module_cache_reg_ram_199__2 dffr $PINS Q=camera_module_cache_ram_199__2
+ QB=#dummy[665] D=nx7713 CLK=clk R=rst
Xix7714 mux21_ni $PINS Y=nx7713 A0=camera_module_cache_ram_199__2 A1=nx35250
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__2 dffr $PINS Q=camera_module_cache_ram_215__2
+ QB=#dummy[666] D=nx7703 CLK=clk R=rst
Xix7704 mux21_ni $PINS Y=nx7703 A0=camera_module_cache_ram_215__2 A1=nx35250
+ S0=nx34592
Xix27106 aoi22 $PINS Y=nx27105 A0=camera_module_cache_ram_231__2 A1=nx36380
+ B0=camera_module_cache_ram_247__2 B1=nx36420
Xcamera_module_cache_reg_ram_231__2 dffr $PINS Q=camera_module_cache_ram_231__2
+ QB=#dummy[667] D=nx7693 CLK=clk R=rst
Xix7694 mux21_ni $PINS Y=nx7693 A0=camera_module_cache_ram_231__2 A1=nx35252
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__2 dffr $PINS Q=camera_module_cache_ram_247__2
+ QB=#dummy[668] D=nx7683 CLK=clk R=rst
Xix7684 mux21_ni $PINS Y=nx7683 A0=camera_module_cache_ram_247__2 A1=nx35252
+ S0=nx34584
Xix10183 nand04 $PINS Y=nx10182 A0=nx27115 A1=nx27197 A2=nx27265 A3=nx27333
Xix27116 oai21 $PINS Y=nx27115 A0=nx10172 A1=nx10094 B0=nx36480
Xix10173 nand04 $PINS Y=nx10172 A0=nx27119 A1=nx27131 A2=nx27142 A3=nx27152
Xix27120 aoi22 $PINS Y=nx27119 A0=camera_module_cache_ram_8__2 A1=nx35820
+ B0=camera_module_cache_ram_24__2 B1=nx35860
Xcamera_module_cache_reg_ram_8__2 dffr $PINS Q=camera_module_cache_ram_8__2
+ QB=#dummy[669] D=nx7673 CLK=clk R=rst
Xix7674 mux21_ni $PINS Y=nx7673 A0=camera_module_cache_ram_8__2 A1=nx35252
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__2 dffr $PINS Q=camera_module_cache_ram_24__2
+ QB=#dummy[670] D=nx7663 CLK=clk R=rst
Xix7664 mux21_ni $PINS Y=nx7663 A0=camera_module_cache_ram_24__2 A1=nx35252
+ S0=nx34570
Xix27132 aoi22 $PINS Y=nx27131 A0=camera_module_cache_ram_40__2 A1=nx35900
+ B0=camera_module_cache_ram_56__2 B1=nx35940
Xcamera_module_cache_reg_ram_40__2 dffr $PINS Q=camera_module_cache_ram_40__2
+ QB=#dummy[671] D=nx7653 CLK=clk R=rst
Xix7654 mux21_ni $PINS Y=nx7653 A0=camera_module_cache_ram_40__2 A1=nx35252
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__2 dffr $PINS Q=camera_module_cache_ram_56__2
+ QB=#dummy[672] D=nx7643 CLK=clk R=rst
Xix7644 mux21_ni $PINS Y=nx7643 A0=camera_module_cache_ram_56__2 A1=nx35252
+ S0=nx34562
Xix27144 aoi22 $PINS Y=nx27142 A0=camera_module_cache_ram_72__2 A1=nx35980
+ B0=camera_module_cache_ram_88__2 B1=nx36020
Xcamera_module_cache_reg_ram_72__2 dffr $PINS Q=camera_module_cache_ram_72__2
+ QB=#dummy[673] D=nx7633 CLK=clk R=rst
Xix7634 mux21_ni $PINS Y=nx7633 A0=camera_module_cache_ram_72__2 A1=nx35252
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__2 dffr $PINS Q=camera_module_cache_ram_88__2
+ QB=#dummy[674] D=nx7623 CLK=clk R=rst
Xix7624 mux21_ni $PINS Y=nx7623 A0=camera_module_cache_ram_88__2 A1=nx35254
+ S0=nx34554
Xix27153 aoi22 $PINS Y=nx27152 A0=camera_module_cache_ram_120__2 A1=nx36060
+ B0=camera_module_cache_ram_104__2 B1=nx36100
Xcamera_module_cache_reg_ram_120__2 dffr $PINS Q=camera_module_cache_ram_120__2
+ QB=#dummy[675] D=nx7603 CLK=clk R=rst
Xix7604 mux21_ni $PINS Y=nx7603 A0=camera_module_cache_ram_120__2 A1=nx35254
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__2 dffr $PINS Q=camera_module_cache_ram_104__2
+ QB=#dummy[676] D=nx7613 CLK=clk R=rst
Xix7614 mux21_ni $PINS Y=nx7613 A0=camera_module_cache_ram_104__2 A1=nx35254
+ S0=nx34550
Xix10095 nand04 $PINS Y=nx10094 A0=nx27163 A1=nx27173 A2=nx27181 A3=nx27189
Xix27164 aoi22 $PINS Y=nx27163 A0=camera_module_cache_ram_136__2 A1=nx36140
+ B0=camera_module_cache_ram_152__2 B1=nx36180
Xcamera_module_cache_reg_ram_136__2 dffr $PINS Q=camera_module_cache_ram_136__2
+ QB=#dummy[677] D=nx7593 CLK=clk R=rst
Xix7594 mux21_ni $PINS Y=nx7593 A0=camera_module_cache_ram_136__2 A1=nx35254
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__2 dffr $PINS Q=camera_module_cache_ram_152__2
+ QB=#dummy[678] D=nx7583 CLK=clk R=rst
Xix7584 mux21_ni $PINS Y=nx7583 A0=camera_module_cache_ram_152__2 A1=nx35254
+ S0=nx34538
Xix27174 aoi22 $PINS Y=nx27173 A0=camera_module_cache_ram_184__2 A1=nx36220
+ B0=camera_module_cache_ram_168__2 B1=nx36260
Xcamera_module_cache_reg_ram_184__2 dffr $PINS Q=camera_module_cache_ram_184__2
+ QB=#dummy[679] D=nx7563 CLK=clk R=rst
Xix7564 mux21_ni $PINS Y=nx7563 A0=camera_module_cache_ram_184__2 A1=nx35254
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__2 dffr $PINS Q=camera_module_cache_ram_168__2
+ QB=#dummy[680] D=nx7573 CLK=clk R=rst
Xix7574 mux21_ni $PINS Y=nx7573 A0=camera_module_cache_ram_168__2 A1=nx35254
+ S0=nx34534
Xix27182 aoi22 $PINS Y=nx27181 A0=camera_module_cache_ram_200__2 A1=nx36300
+ B0=camera_module_cache_ram_216__2 B1=nx36340
Xcamera_module_cache_reg_ram_200__2 dffr $PINS Q=camera_module_cache_ram_200__2
+ QB=#dummy[681] D=nx7553 CLK=clk R=rst
Xix7554 mux21_ni $PINS Y=nx7553 A0=camera_module_cache_ram_200__2 A1=nx35256
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__2 dffr $PINS Q=camera_module_cache_ram_216__2
+ QB=#dummy[682] D=nx7543 CLK=clk R=rst
Xix7544 mux21_ni $PINS Y=nx7543 A0=camera_module_cache_ram_216__2 A1=nx35256
+ S0=nx34522
Xix27190 aoi22 $PINS Y=nx27189 A0=camera_module_cache_ram_232__2 A1=nx36380
+ B0=camera_module_cache_ram_248__2 B1=nx36420
Xcamera_module_cache_reg_ram_232__2 dffr $PINS Q=camera_module_cache_ram_232__2
+ QB=#dummy[683] D=nx7533 CLK=clk R=rst
Xix7534 mux21_ni $PINS Y=nx7533 A0=camera_module_cache_ram_232__2 A1=nx35256
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__2 dffr $PINS Q=camera_module_cache_ram_248__2
+ QB=#dummy[684] D=nx7523 CLK=clk R=rst
Xix7524 mux21_ni $PINS Y=nx7523 A0=camera_module_cache_ram_248__2 A1=nx35256
+ S0=nx34514
Xix27198 oai21 $PINS Y=nx27197 A0=nx10010 A1=nx9932 B0=nx36484
Xix10011 nand04 $PINS Y=nx10010 A0=nx27200 A1=nx27208 A2=nx27216 A3=nx27224
Xix27201 aoi22 $PINS Y=nx27200 A0=camera_module_cache_ram_9__2 A1=nx35820
+ B0=camera_module_cache_ram_25__2 B1=nx35860
Xcamera_module_cache_reg_ram_9__2 dffr $PINS Q=camera_module_cache_ram_9__2
+ QB=#dummy[685] D=nx7513 CLK=clk R=rst
Xix7514 mux21_ni $PINS Y=nx7513 A0=camera_module_cache_ram_9__2 A1=nx35256
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__2 dffr $PINS Q=camera_module_cache_ram_25__2
+ QB=#dummy[686] D=nx7503 CLK=clk R=rst
Xix7504 mux21_ni $PINS Y=nx7503 A0=camera_module_cache_ram_25__2 A1=nx35256
+ S0=nx34500
Xix27209 aoi22 $PINS Y=nx27208 A0=camera_module_cache_ram_41__2 A1=nx35900
+ B0=camera_module_cache_ram_57__2 B1=nx35940
Xcamera_module_cache_reg_ram_41__2 dffr $PINS Q=camera_module_cache_ram_41__2
+ QB=#dummy[687] D=nx7493 CLK=clk R=rst
Xix7494 mux21_ni $PINS Y=nx7493 A0=camera_module_cache_ram_41__2 A1=nx35256
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__2 dffr $PINS Q=camera_module_cache_ram_57__2
+ QB=#dummy[688] D=nx7483 CLK=clk R=rst
Xix7484 mux21_ni $PINS Y=nx7483 A0=camera_module_cache_ram_57__2 A1=nx35258
+ S0=nx34492
Xix27217 aoi22 $PINS Y=nx27216 A0=camera_module_cache_ram_73__2 A1=nx35980
+ B0=camera_module_cache_ram_89__2 B1=nx36020
Xcamera_module_cache_reg_ram_73__2 dffr $PINS Q=camera_module_cache_ram_73__2
+ QB=#dummy[689] D=nx7473 CLK=clk R=rst
Xix7474 mux21_ni $PINS Y=nx7473 A0=camera_module_cache_ram_73__2 A1=nx35258
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__2 dffr $PINS Q=camera_module_cache_ram_89__2
+ QB=#dummy[690] D=nx7463 CLK=clk R=rst
Xix7464 mux21_ni $PINS Y=nx7463 A0=camera_module_cache_ram_89__2 A1=nx35258
+ S0=nx34484
Xix27225 aoi22 $PINS Y=nx27224 A0=camera_module_cache_ram_121__2 A1=nx36060
+ B0=camera_module_cache_ram_105__2 B1=nx36100
Xcamera_module_cache_reg_ram_121__2 dffr $PINS Q=camera_module_cache_ram_121__2
+ QB=#dummy[691] D=nx7443 CLK=clk R=rst
Xix7444 mux21_ni $PINS Y=nx7443 A0=camera_module_cache_ram_121__2 A1=nx35258
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__2 dffr $PINS Q=camera_module_cache_ram_105__2
+ QB=#dummy[692] D=nx7453 CLK=clk R=rst
Xix7454 mux21_ni $PINS Y=nx7453 A0=camera_module_cache_ram_105__2 A1=nx35258
+ S0=nx34480
Xix9933 nand04 $PINS Y=nx9932 A0=nx27233 A1=nx27241 A2=nx27249 A3=nx27257
Xix27234 aoi22 $PINS Y=nx27233 A0=camera_module_cache_ram_137__2 A1=nx36140
+ B0=camera_module_cache_ram_153__2 B1=nx36180
Xcamera_module_cache_reg_ram_137__2 dffr $PINS Q=camera_module_cache_ram_137__2
+ QB=#dummy[693] D=nx7433 CLK=clk R=rst
Xix7434 mux21_ni $PINS Y=nx7433 A0=camera_module_cache_ram_137__2 A1=nx35258
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__2 dffr $PINS Q=camera_module_cache_ram_153__2
+ QB=#dummy[694] D=nx7423 CLK=clk R=rst
Xix7424 mux21_ni $PINS Y=nx7423 A0=camera_module_cache_ram_153__2 A1=nx35258
+ S0=nx34468
Xix27242 aoi22 $PINS Y=nx27241 A0=camera_module_cache_ram_185__2 A1=nx36220
+ B0=camera_module_cache_ram_169__2 B1=nx36260
Xcamera_module_cache_reg_ram_185__2 dffr $PINS Q=camera_module_cache_ram_185__2
+ QB=#dummy[695] D=nx7403 CLK=clk R=rst
Xix7404 mux21_ni $PINS Y=nx7403 A0=camera_module_cache_ram_185__2 A1=nx35260
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__2 dffr $PINS Q=camera_module_cache_ram_169__2
+ QB=#dummy[696] D=nx7413 CLK=clk R=rst
Xix7414 mux21_ni $PINS Y=nx7413 A0=camera_module_cache_ram_169__2 A1=nx35260
+ S0=nx34464
Xix27250 aoi22 $PINS Y=nx27249 A0=camera_module_cache_ram_201__2 A1=nx36300
+ B0=camera_module_cache_ram_217__2 B1=nx36340
Xcamera_module_cache_reg_ram_201__2 dffr $PINS Q=camera_module_cache_ram_201__2
+ QB=#dummy[697] D=nx7393 CLK=clk R=rst
Xix7394 mux21_ni $PINS Y=nx7393 A0=camera_module_cache_ram_201__2 A1=nx35260
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__2 dffr $PINS Q=camera_module_cache_ram_217__2
+ QB=#dummy[698] D=nx7383 CLK=clk R=rst
Xix7384 mux21_ni $PINS Y=nx7383 A0=camera_module_cache_ram_217__2 A1=nx35260
+ S0=nx34452
Xix27258 aoi22 $PINS Y=nx27257 A0=camera_module_cache_ram_233__2 A1=nx36380
+ B0=camera_module_cache_ram_249__2 B1=nx36420
Xcamera_module_cache_reg_ram_233__2 dffr $PINS Q=camera_module_cache_ram_233__2
+ QB=#dummy[699] D=nx7373 CLK=clk R=rst
Xix7374 mux21_ni $PINS Y=nx7373 A0=camera_module_cache_ram_233__2 A1=nx35260
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__2 dffr $PINS Q=camera_module_cache_ram_249__2
+ QB=#dummy[700] D=nx7363 CLK=clk R=rst
Xix7364 mux21_ni $PINS Y=nx7363 A0=camera_module_cache_ram_249__2 A1=nx35260
+ S0=nx34444
Xix27266 oai21 $PINS Y=nx27265 A0=nx9846 A1=nx9768 B0=nx36488
Xix9847 nand04 $PINS Y=nx9846 A0=nx27268 A1=nx27276 A2=nx27284 A3=nx27292
Xix27269 aoi22 $PINS Y=nx27268 A0=camera_module_cache_ram_10__2 A1=nx35820
+ B0=camera_module_cache_ram_26__2 B1=nx35860
Xcamera_module_cache_reg_ram_10__2 dffr $PINS Q=camera_module_cache_ram_10__2
+ QB=#dummy[701] D=nx7353 CLK=clk R=rst
Xix7354 mux21_ni $PINS Y=nx7353 A0=camera_module_cache_ram_10__2 A1=nx35260
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__2 dffr $PINS Q=camera_module_cache_ram_26__2
+ QB=#dummy[702] D=nx7343 CLK=clk R=rst
Xix7344 mux21_ni $PINS Y=nx7343 A0=camera_module_cache_ram_26__2 A1=nx35262
+ S0=nx34430
Xix27277 aoi22 $PINS Y=nx27276 A0=camera_module_cache_ram_42__2 A1=nx35900
+ B0=camera_module_cache_ram_58__2 B1=nx35940
Xcamera_module_cache_reg_ram_42__2 dffr $PINS Q=camera_module_cache_ram_42__2
+ QB=#dummy[703] D=nx7333 CLK=clk R=rst
Xix7334 mux21_ni $PINS Y=nx7333 A0=camera_module_cache_ram_42__2 A1=nx35262
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__2 dffr $PINS Q=camera_module_cache_ram_58__2
+ QB=#dummy[704] D=nx7323 CLK=clk R=rst
Xix7324 mux21_ni $PINS Y=nx7323 A0=camera_module_cache_ram_58__2 A1=nx35262
+ S0=nx34422
Xix27285 aoi22 $PINS Y=nx27284 A0=camera_module_cache_ram_74__2 A1=nx35980
+ B0=camera_module_cache_ram_90__2 B1=nx36020
Xcamera_module_cache_reg_ram_74__2 dffr $PINS Q=camera_module_cache_ram_74__2
+ QB=#dummy[705] D=nx7313 CLK=clk R=rst
Xix7314 mux21_ni $PINS Y=nx7313 A0=camera_module_cache_ram_74__2 A1=nx35262
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__2 dffr $PINS Q=camera_module_cache_ram_90__2
+ QB=#dummy[706] D=nx7303 CLK=clk R=rst
Xix7304 mux21_ni $PINS Y=nx7303 A0=camera_module_cache_ram_90__2 A1=nx35262
+ S0=nx34414
Xix27293 aoi22 $PINS Y=nx27292 A0=camera_module_cache_ram_122__2 A1=nx36060
+ B0=camera_module_cache_ram_106__2 B1=nx36100
Xcamera_module_cache_reg_ram_122__2 dffr $PINS Q=camera_module_cache_ram_122__2
+ QB=#dummy[707] D=nx7283 CLK=clk R=rst
Xix7284 mux21_ni $PINS Y=nx7283 A0=camera_module_cache_ram_122__2 A1=nx35262
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__2 dffr $PINS Q=camera_module_cache_ram_106__2
+ QB=#dummy[708] D=nx7293 CLK=clk R=rst
Xix7294 mux21_ni $PINS Y=nx7293 A0=camera_module_cache_ram_106__2 A1=nx35262
+ S0=nx34410
Xix9769 nand04 $PINS Y=nx9768 A0=nx27301 A1=nx27309 A2=nx27317 A3=nx27325
Xix27302 aoi22 $PINS Y=nx27301 A0=camera_module_cache_ram_138__2 A1=nx36140
+ B0=camera_module_cache_ram_154__2 B1=nx36180
Xcamera_module_cache_reg_ram_138__2 dffr $PINS Q=camera_module_cache_ram_138__2
+ QB=#dummy[709] D=nx7273 CLK=clk R=rst
Xix7274 mux21_ni $PINS Y=nx7273 A0=camera_module_cache_ram_138__2 A1=nx35264
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__2 dffr $PINS Q=camera_module_cache_ram_154__2
+ QB=#dummy[710] D=nx7263 CLK=clk R=rst
Xix7264 mux21_ni $PINS Y=nx7263 A0=camera_module_cache_ram_154__2 A1=nx35264
+ S0=nx34398
Xix27310 aoi22 $PINS Y=nx27309 A0=camera_module_cache_ram_186__2 A1=nx36220
+ B0=camera_module_cache_ram_170__2 B1=nx36260
Xcamera_module_cache_reg_ram_186__2 dffr $PINS Q=camera_module_cache_ram_186__2
+ QB=#dummy[711] D=nx7243 CLK=clk R=rst
Xix7244 mux21_ni $PINS Y=nx7243 A0=camera_module_cache_ram_186__2 A1=nx35264
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__2 dffr $PINS Q=camera_module_cache_ram_170__2
+ QB=#dummy[712] D=nx7253 CLK=clk R=rst
Xix7254 mux21_ni $PINS Y=nx7253 A0=camera_module_cache_ram_170__2 A1=nx35264
+ S0=nx34394
Xix27318 aoi22 $PINS Y=nx27317 A0=camera_module_cache_ram_202__2 A1=nx36300
+ B0=camera_module_cache_ram_218__2 B1=nx36340
Xcamera_module_cache_reg_ram_202__2 dffr $PINS Q=camera_module_cache_ram_202__2
+ QB=#dummy[713] D=nx7233 CLK=clk R=rst
Xix7234 mux21_ni $PINS Y=nx7233 A0=camera_module_cache_ram_202__2 A1=nx35264
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__2 dffr $PINS Q=camera_module_cache_ram_218__2
+ QB=#dummy[714] D=nx7223 CLK=clk R=rst
Xix7224 mux21_ni $PINS Y=nx7223 A0=camera_module_cache_ram_218__2 A1=nx35264
+ S0=nx34382
Xix27326 aoi22 $PINS Y=nx27325 A0=camera_module_cache_ram_234__2 A1=nx36380
+ B0=camera_module_cache_ram_250__2 B1=nx36420
Xcamera_module_cache_reg_ram_234__2 dffr $PINS Q=camera_module_cache_ram_234__2
+ QB=#dummy[715] D=nx7213 CLK=clk R=rst
Xix7214 mux21_ni $PINS Y=nx7213 A0=camera_module_cache_ram_234__2 A1=nx35264
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__2 dffr $PINS Q=camera_module_cache_ram_250__2
+ QB=#dummy[716] D=nx7203 CLK=clk R=rst
Xix7204 mux21_ni $PINS Y=nx7203 A0=camera_module_cache_ram_250__2 A1=nx35266
+ S0=nx34374
Xix27334 oai21 $PINS Y=nx27333 A0=nx9684 A1=nx9606 B0=nx36492
Xix9685 nand04 $PINS Y=nx9684 A0=nx27336 A1=nx27344 A2=nx27352 A3=nx27360
Xix27337 aoi22 $PINS Y=nx27336 A0=camera_module_cache_ram_11__2 A1=nx35820
+ B0=camera_module_cache_ram_27__2 B1=nx35860
Xcamera_module_cache_reg_ram_11__2 dffr $PINS Q=camera_module_cache_ram_11__2
+ QB=#dummy[717] D=nx7193 CLK=clk R=rst
Xix7194 mux21_ni $PINS Y=nx7193 A0=camera_module_cache_ram_11__2 A1=nx35266
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__2 dffr $PINS Q=camera_module_cache_ram_27__2
+ QB=#dummy[718] D=nx7183 CLK=clk R=rst
Xix7184 mux21_ni $PINS Y=nx7183 A0=camera_module_cache_ram_27__2 A1=nx35266
+ S0=nx34360
Xix27345 aoi22 $PINS Y=nx27344 A0=camera_module_cache_ram_43__2 A1=nx35900
+ B0=camera_module_cache_ram_59__2 B1=nx35940
Xcamera_module_cache_reg_ram_43__2 dffr $PINS Q=camera_module_cache_ram_43__2
+ QB=#dummy[719] D=nx7173 CLK=clk R=rst
Xix7174 mux21_ni $PINS Y=nx7173 A0=camera_module_cache_ram_43__2 A1=nx35266
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__2 dffr $PINS Q=camera_module_cache_ram_59__2
+ QB=#dummy[720] D=nx7163 CLK=clk R=rst
Xix7164 mux21_ni $PINS Y=nx7163 A0=camera_module_cache_ram_59__2 A1=nx35266
+ S0=nx34352
Xix27353 aoi22 $PINS Y=nx27352 A0=camera_module_cache_ram_75__2 A1=nx35980
+ B0=camera_module_cache_ram_91__2 B1=nx36020
Xcamera_module_cache_reg_ram_75__2 dffr $PINS Q=camera_module_cache_ram_75__2
+ QB=#dummy[721] D=nx7153 CLK=clk R=rst
Xix7154 mux21_ni $PINS Y=nx7153 A0=camera_module_cache_ram_75__2 A1=nx35266
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__2 dffr $PINS Q=camera_module_cache_ram_91__2
+ QB=#dummy[722] D=nx7143 CLK=clk R=rst
Xix7144 mux21_ni $PINS Y=nx7143 A0=camera_module_cache_ram_91__2 A1=nx35266
+ S0=nx34344
Xix27361 aoi22 $PINS Y=nx27360 A0=camera_module_cache_ram_123__2 A1=nx36060
+ B0=camera_module_cache_ram_107__2 B1=nx36100
Xcamera_module_cache_reg_ram_123__2 dffr $PINS Q=camera_module_cache_ram_123__2
+ QB=#dummy[723] D=nx7123 CLK=clk R=rst
Xix7124 mux21_ni $PINS Y=nx7123 A0=camera_module_cache_ram_123__2 A1=nx35268
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__2 dffr $PINS Q=camera_module_cache_ram_107__2
+ QB=#dummy[724] D=nx7133 CLK=clk R=rst
Xix7134 mux21_ni $PINS Y=nx7133 A0=camera_module_cache_ram_107__2 A1=nx35268
+ S0=nx34340
Xix9607 nand04 $PINS Y=nx9606 A0=nx27369 A1=nx27377 A2=nx27385 A3=nx27393
Xix27370 aoi22 $PINS Y=nx27369 A0=camera_module_cache_ram_139__2 A1=nx36140
+ B0=camera_module_cache_ram_155__2 B1=nx36180
Xcamera_module_cache_reg_ram_139__2 dffr $PINS Q=camera_module_cache_ram_139__2
+ QB=#dummy[725] D=nx7113 CLK=clk R=rst
Xix7114 mux21_ni $PINS Y=nx7113 A0=camera_module_cache_ram_139__2 A1=nx35268
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__2 dffr $PINS Q=camera_module_cache_ram_155__2
+ QB=#dummy[726] D=nx7103 CLK=clk R=rst
Xix7104 mux21_ni $PINS Y=nx7103 A0=camera_module_cache_ram_155__2 A1=nx35268
+ S0=nx34328
Xix27378 aoi22 $PINS Y=nx27377 A0=camera_module_cache_ram_187__2 A1=nx36220
+ B0=camera_module_cache_ram_171__2 B1=nx36260
Xcamera_module_cache_reg_ram_187__2 dffr $PINS Q=camera_module_cache_ram_187__2
+ QB=#dummy[727] D=nx7083 CLK=clk R=rst
Xix7084 mux21_ni $PINS Y=nx7083 A0=camera_module_cache_ram_187__2 A1=nx35268
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__2 dffr $PINS Q=camera_module_cache_ram_171__2
+ QB=#dummy[728] D=nx7093 CLK=clk R=rst
Xix7094 mux21_ni $PINS Y=nx7093 A0=camera_module_cache_ram_171__2 A1=nx35268
+ S0=nx34324
Xix27386 aoi22 $PINS Y=nx27385 A0=camera_module_cache_ram_203__2 A1=nx36300
+ B0=camera_module_cache_ram_219__2 B1=nx36340
Xcamera_module_cache_reg_ram_203__2 dffr $PINS Q=camera_module_cache_ram_203__2
+ QB=#dummy[729] D=nx7073 CLK=clk R=rst
Xix7074 mux21_ni $PINS Y=nx7073 A0=camera_module_cache_ram_203__2 A1=nx35268
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__2 dffr $PINS Q=camera_module_cache_ram_219__2
+ QB=#dummy[730] D=nx7063 CLK=clk R=rst
Xix7064 mux21_ni $PINS Y=nx7063 A0=camera_module_cache_ram_219__2 A1=nx35270
+ S0=nx34312
Xix27394 aoi22 $PINS Y=nx27393 A0=camera_module_cache_ram_235__2 A1=nx36380
+ B0=camera_module_cache_ram_251__2 B1=nx36420
Xcamera_module_cache_reg_ram_235__2 dffr $PINS Q=camera_module_cache_ram_235__2
+ QB=#dummy[731] D=nx7053 CLK=clk R=rst
Xix7054 mux21_ni $PINS Y=nx7053 A0=camera_module_cache_ram_235__2 A1=nx35270
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__2 dffr $PINS Q=camera_module_cache_ram_251__2
+ QB=#dummy[732] D=nx7043 CLK=clk R=rst
Xix7044 mux21_ni $PINS Y=nx7043 A0=camera_module_cache_ram_251__2 A1=nx35270
+ S0=nx34304
Xix9529 nand04 $PINS Y=nx9528 A0=nx27402 A1=nx27470 A2=nx27538 A3=nx27606
Xix27403 oai21 $PINS Y=nx27402 A0=nx9518 A1=nx9440 B0=nx36506
Xix9519 nand04 $PINS Y=nx9518 A0=nx27405 A1=nx27413 A2=nx27421 A3=nx27429
Xix27406 aoi22 $PINS Y=nx27405 A0=camera_module_cache_ram_12__2 A1=nx35820
+ B0=camera_module_cache_ram_28__2 B1=nx35860
Xcamera_module_cache_reg_ram_12__2 dffr $PINS Q=camera_module_cache_ram_12__2
+ QB=#dummy[733] D=nx7033 CLK=clk R=rst
Xix7034 mux21_ni $PINS Y=nx7033 A0=nx35270 A1=camera_module_cache_ram_12__2
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__2 dffr $PINS Q=camera_module_cache_ram_28__2
+ QB=#dummy[734] D=nx7023 CLK=clk R=rst
Xix7024 mux21_ni $PINS Y=nx7023 A0=nx35270 A1=camera_module_cache_ram_28__2
+ S0=nx36510
Xix27414 aoi22 $PINS Y=nx27413 A0=camera_module_cache_ram_44__2 A1=nx35900
+ B0=camera_module_cache_ram_60__2 B1=nx35940
Xcamera_module_cache_reg_ram_44__2 dffr $PINS Q=camera_module_cache_ram_44__2
+ QB=#dummy[735] D=nx7013 CLK=clk R=rst
Xix7014 mux21_ni $PINS Y=nx7013 A0=nx35270 A1=camera_module_cache_ram_44__2
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__2 dffr $PINS Q=camera_module_cache_ram_60__2
+ QB=#dummy[736] D=nx7003 CLK=clk R=rst
Xix7004 mux21_ni $PINS Y=nx7003 A0=nx35270 A1=camera_module_cache_ram_60__2
+ S0=nx36518
Xix27422 aoi22 $PINS Y=nx27421 A0=camera_module_cache_ram_76__2 A1=nx35980
+ B0=camera_module_cache_ram_92__2 B1=nx36020
Xcamera_module_cache_reg_ram_76__2 dffr $PINS Q=camera_module_cache_ram_76__2
+ QB=#dummy[737] D=nx6993 CLK=clk R=rst
Xix6994 mux21_ni $PINS Y=nx6993 A0=nx35272 A1=camera_module_cache_ram_76__2
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__2 dffr $PINS Q=camera_module_cache_ram_92__2
+ QB=#dummy[738] D=nx6983 CLK=clk R=rst
Xix6984 mux21_ni $PINS Y=nx6983 A0=nx35272 A1=camera_module_cache_ram_92__2
+ S0=nx36526
Xix27430 aoi22 $PINS Y=nx27429 A0=camera_module_cache_ram_124__2 A1=nx36060
+ B0=camera_module_cache_ram_108__2 B1=nx36100
Xcamera_module_cache_reg_ram_124__2 dffr $PINS Q=camera_module_cache_ram_124__2
+ QB=#dummy[739] D=nx6963 CLK=clk R=rst
Xix6964 mux21_ni $PINS Y=nx6963 A0=nx35272 A1=camera_module_cache_ram_124__2
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__2 dffr $PINS Q=camera_module_cache_ram_108__2
+ QB=#dummy[740] D=nx6973 CLK=clk R=rst
Xix6974 mux21_ni $PINS Y=nx6973 A0=nx35272 A1=camera_module_cache_ram_108__2
+ S0=nx36534
Xix9441 nand04 $PINS Y=nx9440 A0=nx27438 A1=nx27446 A2=nx27454 A3=nx27462
Xix27439 aoi22 $PINS Y=nx27438 A0=camera_module_cache_ram_140__2 A1=nx36140
+ B0=camera_module_cache_ram_156__2 B1=nx36180
Xcamera_module_cache_reg_ram_140__2 dffr $PINS Q=camera_module_cache_ram_140__2
+ QB=#dummy[741] D=nx6953 CLK=clk R=rst
Xix6954 mux21_ni $PINS Y=nx6953 A0=nx35272 A1=camera_module_cache_ram_140__2
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__2 dffr $PINS Q=camera_module_cache_ram_156__2
+ QB=#dummy[742] D=nx6943 CLK=clk R=rst
Xix6944 mux21_ni $PINS Y=nx6943 A0=nx35272 A1=camera_module_cache_ram_156__2
+ S0=nx36542
Xix27447 aoi22 $PINS Y=nx27446 A0=camera_module_cache_ram_188__2 A1=nx36220
+ B0=camera_module_cache_ram_172__2 B1=nx36260
Xcamera_module_cache_reg_ram_188__2 dffr $PINS Q=camera_module_cache_ram_188__2
+ QB=#dummy[743] D=nx6923 CLK=clk R=rst
Xix6924 mux21_ni $PINS Y=nx6923 A0=nx35272 A1=camera_module_cache_ram_188__2
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__2 dffr $PINS Q=camera_module_cache_ram_172__2
+ QB=#dummy[744] D=nx6933 CLK=clk R=rst
Xix6934 mux21_ni $PINS Y=nx6933 A0=nx35274 A1=camera_module_cache_ram_172__2
+ S0=nx36550
Xix27455 aoi22 $PINS Y=nx27454 A0=camera_module_cache_ram_204__2 A1=nx36300
+ B0=camera_module_cache_ram_220__2 B1=nx36340
Xcamera_module_cache_reg_ram_204__2 dffr $PINS Q=camera_module_cache_ram_204__2
+ QB=#dummy[745] D=nx6913 CLK=clk R=rst
Xix6914 mux21_ni $PINS Y=nx6913 A0=nx35274 A1=camera_module_cache_ram_204__2
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__2 dffr $PINS Q=camera_module_cache_ram_220__2
+ QB=#dummy[746] D=nx6903 CLK=clk R=rst
Xix6904 mux21_ni $PINS Y=nx6903 A0=nx35274 A1=camera_module_cache_ram_220__2
+ S0=nx36558
Xix27463 aoi22 $PINS Y=nx27462 A0=camera_module_cache_ram_236__2 A1=nx36380
+ B0=camera_module_cache_ram_252__2 B1=nx36420
Xcamera_module_cache_reg_ram_236__2 dffr $PINS Q=camera_module_cache_ram_236__2
+ QB=#dummy[747] D=nx6893 CLK=clk R=rst
Xix6894 mux21_ni $PINS Y=nx6893 A0=nx35274 A1=camera_module_cache_ram_236__2
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__2 dffr $PINS Q=camera_module_cache_ram_252__2
+ QB=#dummy[748] D=nx6883 CLK=clk R=rst
Xix6884 mux21_ni $PINS Y=nx6883 A0=nx35274 A1=camera_module_cache_ram_252__2
+ S0=nx36566
Xix27471 oai21 $PINS Y=nx27470 A0=nx9356 A1=nx9278 B0=nx36580
Xix9357 nand04 $PINS Y=nx9356 A0=nx27473 A1=nx27481 A2=nx27489 A3=nx27497
Xix27474 aoi22 $PINS Y=nx27473 A0=camera_module_cache_ram_13__2 A1=nx35822
+ B0=camera_module_cache_ram_29__2 B1=nx35862
Xcamera_module_cache_reg_ram_13__2 dffr $PINS Q=camera_module_cache_ram_13__2
+ QB=#dummy[749] D=nx6873 CLK=clk R=rst
Xix6874 mux21_ni $PINS Y=nx6873 A0=nx35274 A1=camera_module_cache_ram_13__2
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__2 dffr $PINS Q=camera_module_cache_ram_29__2
+ QB=#dummy[750] D=nx6863 CLK=clk R=rst
Xix6864 mux21_ni $PINS Y=nx6863 A0=nx35274 A1=camera_module_cache_ram_29__2
+ S0=nx36584
Xix27482 aoi22 $PINS Y=nx27481 A0=camera_module_cache_ram_45__2 A1=nx35902
+ B0=camera_module_cache_ram_61__2 B1=nx35942
Xcamera_module_cache_reg_ram_45__2 dffr $PINS Q=camera_module_cache_ram_45__2
+ QB=#dummy[751] D=nx6853 CLK=clk R=rst
Xix6854 mux21_ni $PINS Y=nx6853 A0=nx35276 A1=camera_module_cache_ram_45__2
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__2 dffr $PINS Q=camera_module_cache_ram_61__2
+ QB=#dummy[752] D=nx6843 CLK=clk R=rst
Xix6844 mux21_ni $PINS Y=nx6843 A0=nx35276 A1=camera_module_cache_ram_61__2
+ S0=nx36592
Xix27490 aoi22 $PINS Y=nx27489 A0=camera_module_cache_ram_77__2 A1=nx35982
+ B0=camera_module_cache_ram_93__2 B1=nx36022
Xcamera_module_cache_reg_ram_77__2 dffr $PINS Q=camera_module_cache_ram_77__2
+ QB=#dummy[753] D=nx6833 CLK=clk R=rst
Xix6834 mux21_ni $PINS Y=nx6833 A0=nx35276 A1=camera_module_cache_ram_77__2
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__2 dffr $PINS Q=camera_module_cache_ram_93__2
+ QB=#dummy[754] D=nx6823 CLK=clk R=rst
Xix6824 mux21_ni $PINS Y=nx6823 A0=nx35276 A1=camera_module_cache_ram_93__2
+ S0=nx36600
Xix27498 aoi22 $PINS Y=nx27497 A0=camera_module_cache_ram_125__2 A1=nx36062
+ B0=camera_module_cache_ram_109__2 B1=nx36102
Xcamera_module_cache_reg_ram_125__2 dffr $PINS Q=camera_module_cache_ram_125__2
+ QB=#dummy[755] D=nx6803 CLK=clk R=rst
Xix6804 mux21_ni $PINS Y=nx6803 A0=nx35276 A1=camera_module_cache_ram_125__2
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__2 dffr $PINS Q=camera_module_cache_ram_109__2
+ QB=#dummy[756] D=nx6813 CLK=clk R=rst
Xix6814 mux21_ni $PINS Y=nx6813 A0=nx35276 A1=camera_module_cache_ram_109__2
+ S0=nx36608
Xix9279 nand04 $PINS Y=nx9278 A0=nx27506 A1=nx27514 A2=nx27522 A3=nx27530
Xix27507 aoi22 $PINS Y=nx27506 A0=camera_module_cache_ram_141__2 A1=nx36142
+ B0=camera_module_cache_ram_157__2 B1=nx36182
Xcamera_module_cache_reg_ram_141__2 dffr $PINS Q=camera_module_cache_ram_141__2
+ QB=#dummy[757] D=nx6793 CLK=clk R=rst
Xix6794 mux21_ni $PINS Y=nx6793 A0=nx35276 A1=camera_module_cache_ram_141__2
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__2 dffr $PINS Q=camera_module_cache_ram_157__2
+ QB=#dummy[758] D=nx6783 CLK=clk R=rst
Xix6784 mux21_ni $PINS Y=nx6783 A0=nx35278 A1=camera_module_cache_ram_157__2
+ S0=nx36616
Xix27515 aoi22 $PINS Y=nx27514 A0=camera_module_cache_ram_189__2 A1=nx36222
+ B0=camera_module_cache_ram_173__2 B1=nx36262
Xcamera_module_cache_reg_ram_189__2 dffr $PINS Q=camera_module_cache_ram_189__2
+ QB=#dummy[759] D=nx6763 CLK=clk R=rst
Xix6764 mux21_ni $PINS Y=nx6763 A0=nx35278 A1=camera_module_cache_ram_189__2
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__2 dffr $PINS Q=camera_module_cache_ram_173__2
+ QB=#dummy[760] D=nx6773 CLK=clk R=rst
Xix6774 mux21_ni $PINS Y=nx6773 A0=nx35278 A1=camera_module_cache_ram_173__2
+ S0=nx36624
Xix27523 aoi22 $PINS Y=nx27522 A0=camera_module_cache_ram_205__2 A1=nx36302
+ B0=camera_module_cache_ram_221__2 B1=nx36342
Xcamera_module_cache_reg_ram_205__2 dffr $PINS Q=camera_module_cache_ram_205__2
+ QB=#dummy[761] D=nx6753 CLK=clk R=rst
Xix6754 mux21_ni $PINS Y=nx6753 A0=nx35278 A1=camera_module_cache_ram_205__2
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__2 dffr $PINS Q=camera_module_cache_ram_221__2
+ QB=#dummy[762] D=nx6743 CLK=clk R=rst
Xix6744 mux21_ni $PINS Y=nx6743 A0=nx35278 A1=camera_module_cache_ram_221__2
+ S0=nx36632
Xix27531 aoi22 $PINS Y=nx27530 A0=camera_module_cache_ram_237__2 A1=nx36382
+ B0=camera_module_cache_ram_253__2 B1=nx36422
Xcamera_module_cache_reg_ram_237__2 dffr $PINS Q=camera_module_cache_ram_237__2
+ QB=#dummy[763] D=nx6733 CLK=clk R=rst
Xix6734 mux21_ni $PINS Y=nx6733 A0=nx35278 A1=camera_module_cache_ram_237__2
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__2 dffr $PINS Q=camera_module_cache_ram_253__2
+ QB=#dummy[764] D=nx6723 CLK=clk R=rst
Xix6724 mux21_ni $PINS Y=nx6723 A0=nx35278 A1=camera_module_cache_ram_253__2
+ S0=nx36640
Xix27539 oai21 $PINS Y=nx27538 A0=nx9192 A1=nx9114 B0=nx36654
Xix9193 nand04 $PINS Y=nx9192 A0=nx27541 A1=nx27549 A2=nx27557 A3=nx27565
Xix27542 aoi22 $PINS Y=nx27541 A0=camera_module_cache_ram_14__2 A1=nx35822
+ B0=camera_module_cache_ram_30__2 B1=nx35862
Xcamera_module_cache_reg_ram_14__2 dffr $PINS Q=camera_module_cache_ram_14__2
+ QB=#dummy[765] D=nx6713 CLK=clk R=rst
Xix6714 mux21_ni $PINS Y=nx6713 A0=nx35280 A1=camera_module_cache_ram_14__2
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__2 dffr $PINS Q=camera_module_cache_ram_30__2
+ QB=#dummy[766] D=nx6703 CLK=clk R=rst
Xix6704 mux21_ni $PINS Y=nx6703 A0=nx35280 A1=camera_module_cache_ram_30__2
+ S0=nx36658
Xix27550 aoi22 $PINS Y=nx27549 A0=camera_module_cache_ram_46__2 A1=nx35902
+ B0=camera_module_cache_ram_62__2 B1=nx35942
Xcamera_module_cache_reg_ram_46__2 dffr $PINS Q=camera_module_cache_ram_46__2
+ QB=#dummy[767] D=nx6693 CLK=clk R=rst
Xix6694 mux21_ni $PINS Y=nx6693 A0=nx35280 A1=camera_module_cache_ram_46__2
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__2 dffr $PINS Q=camera_module_cache_ram_62__2
+ QB=#dummy[768] D=nx6683 CLK=clk R=rst
Xix6684 mux21_ni $PINS Y=nx6683 A0=nx35280 A1=camera_module_cache_ram_62__2
+ S0=nx36666
Xix27558 aoi22 $PINS Y=nx27557 A0=camera_module_cache_ram_78__2 A1=nx35982
+ B0=camera_module_cache_ram_94__2 B1=nx36022
Xcamera_module_cache_reg_ram_78__2 dffr $PINS Q=camera_module_cache_ram_78__2
+ QB=#dummy[769] D=nx6673 CLK=clk R=rst
Xix6674 mux21_ni $PINS Y=nx6673 A0=nx35280 A1=camera_module_cache_ram_78__2
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__2 dffr $PINS Q=camera_module_cache_ram_94__2
+ QB=#dummy[770] D=nx6663 CLK=clk R=rst
Xix6664 mux21_ni $PINS Y=nx6663 A0=nx35280 A1=camera_module_cache_ram_94__2
+ S0=nx36674
Xix27566 aoi22 $PINS Y=nx27565 A0=camera_module_cache_ram_126__2 A1=nx36062
+ B0=camera_module_cache_ram_110__2 B1=nx36102
Xcamera_module_cache_reg_ram_126__2 dffr $PINS Q=camera_module_cache_ram_126__2
+ QB=#dummy[771] D=nx6643 CLK=clk R=rst
Xix6644 mux21_ni $PINS Y=nx6643 A0=nx35280 A1=camera_module_cache_ram_126__2
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__2 dffr $PINS Q=camera_module_cache_ram_110__2
+ QB=#dummy[772] D=nx6653 CLK=clk R=rst
Xix6654 mux21_ni $PINS Y=nx6653 A0=nx35282 A1=camera_module_cache_ram_110__2
+ S0=nx36682
Xix9115 nand04 $PINS Y=nx9114 A0=nx27574 A1=nx27582 A2=nx27590 A3=nx27598
Xix27575 aoi22 $PINS Y=nx27574 A0=camera_module_cache_ram_142__2 A1=nx36142
+ B0=camera_module_cache_ram_158__2 B1=nx36182
Xcamera_module_cache_reg_ram_142__2 dffr $PINS Q=camera_module_cache_ram_142__2
+ QB=#dummy[773] D=nx6633 CLK=clk R=rst
Xix6634 mux21_ni $PINS Y=nx6633 A0=nx35282 A1=camera_module_cache_ram_142__2
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__2 dffr $PINS Q=camera_module_cache_ram_158__2
+ QB=#dummy[774] D=nx6623 CLK=clk R=rst
Xix6624 mux21_ni $PINS Y=nx6623 A0=nx35282 A1=camera_module_cache_ram_158__2
+ S0=nx36690
Xix27583 aoi22 $PINS Y=nx27582 A0=camera_module_cache_ram_190__2 A1=nx36222
+ B0=camera_module_cache_ram_174__2 B1=nx36262
Xcamera_module_cache_reg_ram_190__2 dffr $PINS Q=camera_module_cache_ram_190__2
+ QB=#dummy[775] D=nx6603 CLK=clk R=rst
Xix6604 mux21_ni $PINS Y=nx6603 A0=nx35282 A1=camera_module_cache_ram_190__2
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__2 dffr $PINS Q=camera_module_cache_ram_174__2
+ QB=#dummy[776] D=nx6613 CLK=clk R=rst
Xix6614 mux21_ni $PINS Y=nx6613 A0=nx35282 A1=camera_module_cache_ram_174__2
+ S0=nx36698
Xix27591 aoi22 $PINS Y=nx27590 A0=camera_module_cache_ram_206__2 A1=nx36302
+ B0=camera_module_cache_ram_222__2 B1=nx36342
Xcamera_module_cache_reg_ram_206__2 dffr $PINS Q=camera_module_cache_ram_206__2
+ QB=#dummy[777] D=nx6593 CLK=clk R=rst
Xix6594 mux21_ni $PINS Y=nx6593 A0=nx35282 A1=camera_module_cache_ram_206__2
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__2 dffr $PINS Q=camera_module_cache_ram_222__2
+ QB=#dummy[778] D=nx6583 CLK=clk R=rst
Xix6584 mux21_ni $PINS Y=nx6583 A0=nx35282 A1=camera_module_cache_ram_222__2
+ S0=nx36706
Xix27599 aoi22 $PINS Y=nx27598 A0=camera_module_cache_ram_238__2 A1=nx36382
+ B0=camera_module_cache_ram_254__2 B1=nx36422
Xcamera_module_cache_reg_ram_238__2 dffr $PINS Q=camera_module_cache_ram_238__2
+ QB=#dummy[779] D=nx6573 CLK=clk R=rst
Xix6574 mux21_ni $PINS Y=nx6573 A0=nx35284 A1=camera_module_cache_ram_238__2
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__2 dffr $PINS Q=camera_module_cache_ram_254__2
+ QB=#dummy[780] D=nx6563 CLK=clk R=rst
Xix6564 mux21_ni $PINS Y=nx6563 A0=nx35284 A1=camera_module_cache_ram_254__2
+ S0=nx36714
Xix27607 oai21 $PINS Y=nx27606 A0=nx9030 A1=nx8952 B0=nx36728
Xix9031 nand04 $PINS Y=nx9030 A0=nx27609 A1=nx27617 A2=nx27625 A3=nx27633
Xix27610 aoi22 $PINS Y=nx27609 A0=camera_module_cache_ram_15__2 A1=nx35822
+ B0=camera_module_cache_ram_31__2 B1=nx35862
Xcamera_module_cache_reg_ram_15__2 dffr $PINS Q=camera_module_cache_ram_15__2
+ QB=#dummy[781] D=nx6553 CLK=clk R=rst
Xix6554 mux21_ni $PINS Y=nx6553 A0=nx35284 A1=camera_module_cache_ram_15__2
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__2 dffr $PINS Q=camera_module_cache_ram_31__2
+ QB=#dummy[782] D=nx6543 CLK=clk R=rst
Xix6544 mux21_ni $PINS Y=nx6543 A0=nx35284 A1=camera_module_cache_ram_31__2
+ S0=nx36732
Xix27618 aoi22 $PINS Y=nx27617 A0=camera_module_cache_ram_47__2 A1=nx35902
+ B0=camera_module_cache_ram_63__2 B1=nx35942
Xcamera_module_cache_reg_ram_47__2 dffr $PINS Q=camera_module_cache_ram_47__2
+ QB=#dummy[783] D=nx6533 CLK=clk R=rst
Xix6534 mux21_ni $PINS Y=nx6533 A0=nx35284 A1=camera_module_cache_ram_47__2
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__2 dffr $PINS Q=camera_module_cache_ram_63__2
+ QB=#dummy[784] D=nx6523 CLK=clk R=rst
Xix6524 mux21_ni $PINS Y=nx6523 A0=nx35284 A1=camera_module_cache_ram_63__2
+ S0=nx36740
Xix27626 aoi22 $PINS Y=nx27625 A0=camera_module_cache_ram_79__2 A1=nx35982
+ B0=camera_module_cache_ram_95__2 B1=nx36022
Xcamera_module_cache_reg_ram_79__2 dffr $PINS Q=camera_module_cache_ram_79__2
+ QB=#dummy[785] D=nx6513 CLK=clk R=rst
Xix6514 mux21_ni $PINS Y=nx6513 A0=nx35284 A1=camera_module_cache_ram_79__2
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__2 dffr $PINS Q=camera_module_cache_ram_95__2
+ QB=#dummy[786] D=nx6503 CLK=clk R=rst
Xix6504 mux21_ni $PINS Y=nx6503 A0=nx35286 A1=camera_module_cache_ram_95__2
+ S0=nx36748
Xix27634 aoi22 $PINS Y=nx27633 A0=camera_module_cache_ram_127__2 A1=nx36062
+ B0=camera_module_cache_ram_111__2 B1=nx36102
Xcamera_module_cache_reg_ram_127__2 dffr $PINS Q=camera_module_cache_ram_127__2
+ QB=#dummy[787] D=nx6483 CLK=clk R=rst
Xix6484 mux21_ni $PINS Y=nx6483 A0=nx35286 A1=camera_module_cache_ram_127__2
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__2 dffr $PINS Q=camera_module_cache_ram_111__2
+ QB=#dummy[788] D=nx6493 CLK=clk R=rst
Xix6494 mux21_ni $PINS Y=nx6493 A0=nx35286 A1=camera_module_cache_ram_111__2
+ S0=nx36756
Xix8953 nand04 $PINS Y=nx8952 A0=nx27642 A1=nx27650 A2=nx27658 A3=nx27666
Xix27643 aoi22 $PINS Y=nx27642 A0=camera_module_cache_ram_143__2 A1=nx36142
+ B0=camera_module_cache_ram_159__2 B1=nx36182
Xcamera_module_cache_reg_ram_143__2 dffr $PINS Q=camera_module_cache_ram_143__2
+ QB=#dummy[789] D=nx6473 CLK=clk R=rst
Xix6474 mux21_ni $PINS Y=nx6473 A0=nx35286 A1=camera_module_cache_ram_143__2
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__2 dffr $PINS Q=camera_module_cache_ram_159__2
+ QB=#dummy[790] D=nx6463 CLK=clk R=rst
Xix6464 mux21_ni $PINS Y=nx6463 A0=nx35286 A1=camera_module_cache_ram_159__2
+ S0=nx36764
Xix27651 aoi22 $PINS Y=nx27650 A0=camera_module_cache_ram_191__2 A1=nx36222
+ B0=camera_module_cache_ram_175__2 B1=nx36262
Xcamera_module_cache_reg_ram_191__2 dffr $PINS Q=camera_module_cache_ram_191__2
+ QB=#dummy[791] D=nx6443 CLK=clk R=rst
Xix6444 mux21_ni $PINS Y=nx6443 A0=nx35286 A1=camera_module_cache_ram_191__2
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__2 dffr $PINS Q=camera_module_cache_ram_175__2
+ QB=#dummy[792] D=nx6453 CLK=clk R=rst
Xix6454 mux21_ni $PINS Y=nx6453 A0=nx35286 A1=camera_module_cache_ram_175__2
+ S0=nx36772
Xix27659 aoi22 $PINS Y=nx27658 A0=camera_module_cache_ram_207__2 A1=nx36302
+ B0=camera_module_cache_ram_223__2 B1=nx36342
Xcamera_module_cache_reg_ram_207__2 dffr $PINS Q=camera_module_cache_ram_207__2
+ QB=#dummy[793] D=nx6433 CLK=clk R=rst
Xix6434 mux21_ni $PINS Y=nx6433 A0=nx35288 A1=camera_module_cache_ram_207__2
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__2 dffr $PINS Q=camera_module_cache_ram_223__2
+ QB=#dummy[794] D=nx6423 CLK=clk R=rst
Xix6424 mux21_ni $PINS Y=nx6423 A0=nx35288 A1=camera_module_cache_ram_223__2
+ S0=nx36780
Xix27667 aoi22 $PINS Y=nx27666 A0=camera_module_cache_ram_239__2 A1=nx36382
+ B0=camera_module_cache_ram_255__2 B1=nx36422
Xcamera_module_cache_reg_ram_239__2 dffr $PINS Q=camera_module_cache_ram_239__2
+ QB=#dummy[795] D=nx6413 CLK=clk R=rst
Xix6414 mux21_ni $PINS Y=nx6413 A0=nx35288 A1=camera_module_cache_ram_239__2
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__2 dffr $PINS Q=camera_module_cache_ram_255__2
+ QB=#dummy[796] D=nx6403 CLK=clk R=rst
Xix6404 mux21_ni $PINS Y=nx6403 A0=nx35288 A1=camera_module_cache_ram_255__2
+ S0=nx36788
Xix8755 oai22 $PINS Y=nx8754 A0=nx27676 A1=nx28817 B0=nx29956 B1=nx8730
Xix27677 aoi22 $PINS Y=nx27676 A0=camera_module_algo_module_pixel_value_0
+ A1=nx27681 B0=one B1=nx5972
Xcamera_module_algo_module_pixel_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_pixel_value_0 QB=#dummy[797] D=nx3823 CLK=clk
Xix3824 mux21_ni $PINS Y=nx3823 A0=nx5964
+ A1=camera_module_algo_module_pixel_value_0 S0=nx37152
Xix27682 mux21_ni $PINS Y=nx27681 A0=nx27683 A1=nx35674 S0=nx36792
Xix27684 nor04 $PINS Y=nx27683 A0=nx5944 A1=nx4768 A2=nx3588 A3=nx2410
Xix5945 nand04 $PINS Y=nx5944 A0=nx27686 A1=nx27792 A2=nx27860 A3=nx27928
Xix27687 oai21 $PINS Y=nx27686 A0=nx5934 A1=nx5792 B0=nx36448
Xix5935 nand04 $PINS Y=nx5934 A0=nx27689 A1=nx27735 A2=nx27743 A3=nx27751
Xix27690 aoi22 $PINS Y=nx27689 A0=camera_module_cache_ram_0__0 A1=nx35822
+ B0=camera_module_cache_ram_16__0 B1=nx35862
Xcamera_module_cache_reg_ram_0__0 dffr $PINS Q=camera_module_cache_ram_0__0
+ QB=#dummy[798] D=nx3813 CLK=clk R=rst
Xix3814 mux21_ni $PINS Y=nx3813 A0=camera_module_cache_ram_0__0 A1=nx34164
+ S0=nx35134
Xix1187 oai221 $PINS Y=nx1186 A0=nx34074 A1=nx27694 B0=nx27710 B1=nx35712
+ C0=nx27713
Xnvm_module_tri_dataout_120 tri01 $PINS Y=nvm_data_120 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_112 tri01 $PINS Y=nvm_data_112 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_104 tri01 $PINS Y=nvm_data_104 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_96 tri01 $PINS Y=nvm_data_96 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_88 tri01 $PINS Y=nvm_data_88 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_80 tri01 $PINS Y=nvm_data_80 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_72 tri01 $PINS Y=nvm_data_72 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_64 tri01 $PINS Y=nvm_data_64 A=nx22549
+ E=nvm_module_GND0
Xix27711 inv01 $PINS Y=nx27710 A=nvm_data_0
Xnvm_module_tri_dataout_0 tri01 $PINS Y=nvm_data_0 A=nx22549 E=nvm_module_GND0
Xix27714 nand02 $PINS Y=nx27713 A0=nx34074 A1=nx1120
Xnvm_module_tri_dataout_56 tri01 $PINS Y=nvm_data_56 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_48 tri01 $PINS Y=nvm_data_48 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_40 tri01 $PINS Y=nvm_data_40 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_32 tri01 $PINS Y=nvm_data_32 A=nx22549
+ E=nvm_module_GND0
Xix1089 oai22 $PINS Y=nx1088 A0=nx34104 A1=nx27724 B0=nx34086 B1=nx27728
Xnvm_module_tri_dataout_24 tri01 $PINS Y=nvm_data_24 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_16 tri01 $PINS Y=nvm_data_16 A=nx22549
+ E=nvm_module_GND0
Xix27729 nand02 $PINS Y=nx27728 A0=nvm_data_8 A1=nx34104
Xnvm_module_tri_dataout_8 tri01 $PINS Y=nvm_data_8 A=nx22549 E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__0 dffr $PINS Q=camera_module_cache_ram_16__0
+ QB=#dummy[799] D=nx3803 CLK=clk R=rst
Xix3804 mux21_ni $PINS Y=nx3803 A0=camera_module_cache_ram_16__0 A1=nx34164
+ S0=nx35130
Xix27736 aoi22 $PINS Y=nx27735 A0=camera_module_cache_ram_32__0 A1=nx35902
+ B0=camera_module_cache_ram_48__0 B1=nx35942
Xcamera_module_cache_reg_ram_32__0 dffr $PINS Q=camera_module_cache_ram_32__0
+ QB=#dummy[800] D=nx3793 CLK=clk R=rst
Xix3794 mux21_ni $PINS Y=nx3793 A0=camera_module_cache_ram_32__0 A1=nx34164
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__0 dffr $PINS Q=camera_module_cache_ram_48__0
+ QB=#dummy[801] D=nx3783 CLK=clk R=rst
Xix3784 mux21_ni $PINS Y=nx3783 A0=camera_module_cache_ram_48__0 A1=nx34164
+ S0=nx35122
Xix27744 aoi22 $PINS Y=nx27743 A0=camera_module_cache_ram_64__0 A1=nx35982
+ B0=camera_module_cache_ram_80__0 B1=nx36022
Xcamera_module_cache_reg_ram_64__0 dffr $PINS Q=camera_module_cache_ram_64__0
+ QB=#dummy[802] D=nx3773 CLK=clk R=rst
Xix3774 mux21_ni $PINS Y=nx3773 A0=camera_module_cache_ram_64__0 A1=nx34164
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__0 dffr $PINS Q=camera_module_cache_ram_80__0
+ QB=#dummy[803] D=nx3763 CLK=clk R=rst
Xix3764 mux21_ni $PINS Y=nx3763 A0=camera_module_cache_ram_80__0 A1=nx34164
+ S0=nx35114
Xix27752 aoi22 $PINS Y=nx27751 A0=camera_module_cache_ram_112__0 A1=nx36062
+ B0=camera_module_cache_ram_96__0 B1=nx36102
Xcamera_module_cache_reg_ram_112__0 dffr $PINS Q=camera_module_cache_ram_112__0
+ QB=#dummy[804] D=nx3743 CLK=clk R=rst
Xix3744 mux21_ni $PINS Y=nx3743 A0=camera_module_cache_ram_112__0 A1=nx34164
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__0 dffr $PINS Q=camera_module_cache_ram_96__0
+ QB=#dummy[805] D=nx3753 CLK=clk R=rst
Xix3754 mux21_ni $PINS Y=nx3753 A0=camera_module_cache_ram_96__0 A1=nx34166
+ S0=nx35110
Xix5793 nand04 $PINS Y=nx5792 A0=nx27760 A1=nx27768 A2=nx27776 A3=nx27784
Xix27761 aoi22 $PINS Y=nx27760 A0=camera_module_cache_ram_128__0 A1=nx36142
+ B0=camera_module_cache_ram_144__0 B1=nx36182
Xcamera_module_cache_reg_ram_128__0 dffr $PINS Q=camera_module_cache_ram_128__0
+ QB=#dummy[806] D=nx3733 CLK=clk R=rst
Xix3734 mux21_ni $PINS Y=nx3733 A0=camera_module_cache_ram_128__0 A1=nx34166
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__0 dffr $PINS Q=camera_module_cache_ram_144__0
+ QB=#dummy[807] D=nx3723 CLK=clk R=rst
Xix3724 mux21_ni $PINS Y=nx3723 A0=camera_module_cache_ram_144__0 A1=nx34166
+ S0=nx35098
Xix27769 aoi22 $PINS Y=nx27768 A0=camera_module_cache_ram_176__0 A1=nx36222
+ B0=camera_module_cache_ram_160__0 B1=nx36262
Xcamera_module_cache_reg_ram_176__0 dffr $PINS Q=camera_module_cache_ram_176__0
+ QB=#dummy[808] D=nx3703 CLK=clk R=rst
Xix3704 mux21_ni $PINS Y=nx3703 A0=camera_module_cache_ram_176__0 A1=nx34166
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__0 dffr $PINS Q=camera_module_cache_ram_160__0
+ QB=#dummy[809] D=nx3713 CLK=clk R=rst
Xix3714 mux21_ni $PINS Y=nx3713 A0=camera_module_cache_ram_160__0 A1=nx34166
+ S0=nx35094
Xix27777 aoi22 $PINS Y=nx27776 A0=camera_module_cache_ram_192__0 A1=nx36302
+ B0=camera_module_cache_ram_208__0 B1=nx36342
Xcamera_module_cache_reg_ram_192__0 dffr $PINS Q=camera_module_cache_ram_192__0
+ QB=#dummy[810] D=nx3693 CLK=clk R=rst
Xix3694 mux21_ni $PINS Y=nx3693 A0=camera_module_cache_ram_192__0 A1=nx34166
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__0 dffr $PINS Q=camera_module_cache_ram_208__0
+ QB=#dummy[811] D=nx3683 CLK=clk R=rst
Xix3684 mux21_ni $PINS Y=nx3683 A0=camera_module_cache_ram_208__0 A1=nx34166
+ S0=nx35082
Xix27785 aoi22 $PINS Y=nx27784 A0=camera_module_cache_ram_224__0 A1=nx36382
+ B0=camera_module_cache_ram_240__0 B1=nx36422
Xcamera_module_cache_reg_ram_224__0 dffr $PINS Q=camera_module_cache_ram_224__0
+ QB=#dummy[812] D=nx3673 CLK=clk R=rst
Xix3674 mux21_ni $PINS Y=nx3673 A0=camera_module_cache_ram_224__0 A1=nx34168
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__0 dffr $PINS Q=camera_module_cache_ram_240__0
+ QB=#dummy[813] D=nx3663 CLK=clk R=rst
Xix3664 mux21_ni $PINS Y=nx3663 A0=camera_module_cache_ram_240__0 A1=nx34168
+ S0=nx35074
Xix27793 oai21 $PINS Y=nx27792 A0=nx5642 A1=nx5500 B0=nx36452
Xix5643 nand04 $PINS Y=nx5642 A0=nx27795 A1=nx27803 A2=nx27811 A3=nx27819
Xix27796 aoi22 $PINS Y=nx27795 A0=camera_module_cache_ram_1__0 A1=nx35822
+ B0=camera_module_cache_ram_17__0 B1=nx35862
Xcamera_module_cache_reg_ram_1__0 dffr $PINS Q=camera_module_cache_ram_1__0
+ QB=#dummy[814] D=nx3653 CLK=clk R=rst
Xix3654 mux21_ni $PINS Y=nx3653 A0=camera_module_cache_ram_1__0 A1=nx34168
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__0 dffr $PINS Q=camera_module_cache_ram_17__0
+ QB=#dummy[815] D=nx3643 CLK=clk R=rst
Xix3644 mux21_ni $PINS Y=nx3643 A0=camera_module_cache_ram_17__0 A1=nx34168
+ S0=nx35060
Xix27804 aoi22 $PINS Y=nx27803 A0=camera_module_cache_ram_33__0 A1=nx35902
+ B0=camera_module_cache_ram_49__0 B1=nx35942
Xcamera_module_cache_reg_ram_33__0 dffr $PINS Q=camera_module_cache_ram_33__0
+ QB=#dummy[816] D=nx3633 CLK=clk R=rst
Xix3634 mux21_ni $PINS Y=nx3633 A0=camera_module_cache_ram_33__0 A1=nx34168
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__0 dffr $PINS Q=camera_module_cache_ram_49__0
+ QB=#dummy[817] D=nx3623 CLK=clk R=rst
Xix3624 mux21_ni $PINS Y=nx3623 A0=camera_module_cache_ram_49__0 A1=nx34168
+ S0=nx35052
Xix27812 aoi22 $PINS Y=nx27811 A0=camera_module_cache_ram_65__0 A1=nx35982
+ B0=camera_module_cache_ram_81__0 B1=nx36022
Xcamera_module_cache_reg_ram_65__0 dffr $PINS Q=camera_module_cache_ram_65__0
+ QB=#dummy[818] D=nx3613 CLK=clk R=rst
Xix3614 mux21_ni $PINS Y=nx3613 A0=camera_module_cache_ram_65__0 A1=nx34168
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__0 dffr $PINS Q=camera_module_cache_ram_81__0
+ QB=#dummy[819] D=nx3603 CLK=clk R=rst
Xix3604 mux21_ni $PINS Y=nx3603 A0=camera_module_cache_ram_81__0 A1=nx34170
+ S0=nx35044
Xix27820 aoi22 $PINS Y=nx27819 A0=camera_module_cache_ram_113__0 A1=nx36062
+ B0=camera_module_cache_ram_97__0 B1=nx36102
Xcamera_module_cache_reg_ram_113__0 dffr $PINS Q=camera_module_cache_ram_113__0
+ QB=#dummy[820] D=nx3583 CLK=clk R=rst
Xix3584 mux21_ni $PINS Y=nx3583 A0=camera_module_cache_ram_113__0 A1=nx34170
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__0 dffr $PINS Q=camera_module_cache_ram_97__0
+ QB=#dummy[821] D=nx3593 CLK=clk R=rst
Xix3594 mux21_ni $PINS Y=nx3593 A0=camera_module_cache_ram_97__0 A1=nx34170
+ S0=nx35040
Xix5501 nand04 $PINS Y=nx5500 A0=nx27828 A1=nx27836 A2=nx27844 A3=nx27852
Xix27829 aoi22 $PINS Y=nx27828 A0=camera_module_cache_ram_129__0 A1=nx36142
+ B0=camera_module_cache_ram_145__0 B1=nx36182
Xcamera_module_cache_reg_ram_129__0 dffr $PINS Q=camera_module_cache_ram_129__0
+ QB=#dummy[822] D=nx3573 CLK=clk R=rst
Xix3574 mux21_ni $PINS Y=nx3573 A0=camera_module_cache_ram_129__0 A1=nx34170
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__0 dffr $PINS Q=camera_module_cache_ram_145__0
+ QB=#dummy[823] D=nx3563 CLK=clk R=rst
Xix3564 mux21_ni $PINS Y=nx3563 A0=camera_module_cache_ram_145__0 A1=nx34170
+ S0=nx35028
Xix27837 aoi22 $PINS Y=nx27836 A0=camera_module_cache_ram_177__0 A1=nx36222
+ B0=camera_module_cache_ram_161__0 B1=nx36262
Xcamera_module_cache_reg_ram_177__0 dffr $PINS Q=camera_module_cache_ram_177__0
+ QB=#dummy[824] D=nx3543 CLK=clk R=rst
Xix3544 mux21_ni $PINS Y=nx3543 A0=camera_module_cache_ram_177__0 A1=nx34170
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__0 dffr $PINS Q=camera_module_cache_ram_161__0
+ QB=#dummy[825] D=nx3553 CLK=clk R=rst
Xix3554 mux21_ni $PINS Y=nx3553 A0=camera_module_cache_ram_161__0 A1=nx34170
+ S0=nx35024
Xix27845 aoi22 $PINS Y=nx27844 A0=camera_module_cache_ram_193__0 A1=nx36302
+ B0=camera_module_cache_ram_209__0 B1=nx36342
Xcamera_module_cache_reg_ram_193__0 dffr $PINS Q=camera_module_cache_ram_193__0
+ QB=#dummy[826] D=nx3533 CLK=clk R=rst
Xix3534 mux21_ni $PINS Y=nx3533 A0=camera_module_cache_ram_193__0 A1=nx34172
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__0 dffr $PINS Q=camera_module_cache_ram_209__0
+ QB=#dummy[827] D=nx3523 CLK=clk R=rst
Xix3524 mux21_ni $PINS Y=nx3523 A0=camera_module_cache_ram_209__0 A1=nx34172
+ S0=nx35012
Xix27853 aoi22 $PINS Y=nx27852 A0=camera_module_cache_ram_225__0 A1=nx36382
+ B0=camera_module_cache_ram_241__0 B1=nx36422
Xcamera_module_cache_reg_ram_225__0 dffr $PINS Q=camera_module_cache_ram_225__0
+ QB=#dummy[828] D=nx3513 CLK=clk R=rst
Xix3514 mux21_ni $PINS Y=nx3513 A0=camera_module_cache_ram_225__0 A1=nx34172
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__0 dffr $PINS Q=camera_module_cache_ram_241__0
+ QB=#dummy[829] D=nx3503 CLK=clk R=rst
Xix3504 mux21_ni $PINS Y=nx3503 A0=camera_module_cache_ram_241__0 A1=nx34172
+ S0=nx35004
Xix27861 oai21 $PINS Y=nx27860 A0=nx5348 A1=nx5206 B0=nx36456
Xix5349 nand04 $PINS Y=nx5348 A0=nx27863 A1=nx27871 A2=nx27879 A3=nx27887
Xix27864 aoi22 $PINS Y=nx27863 A0=camera_module_cache_ram_2__0 A1=nx35822
+ B0=camera_module_cache_ram_18__0 B1=nx35862
Xcamera_module_cache_reg_ram_2__0 dffr $PINS Q=camera_module_cache_ram_2__0
+ QB=#dummy[830] D=nx3493 CLK=clk R=rst
Xix3494 mux21_ni $PINS Y=nx3493 A0=camera_module_cache_ram_2__0 A1=nx34172
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__0 dffr $PINS Q=camera_module_cache_ram_18__0
+ QB=#dummy[831] D=nx3483 CLK=clk R=rst
Xix3484 mux21_ni $PINS Y=nx3483 A0=camera_module_cache_ram_18__0 A1=nx34172
+ S0=nx34990
Xix27872 aoi22 $PINS Y=nx27871 A0=camera_module_cache_ram_34__0 A1=nx35902
+ B0=camera_module_cache_ram_50__0 B1=nx35942
Xcamera_module_cache_reg_ram_34__0 dffr $PINS Q=camera_module_cache_ram_34__0
+ QB=#dummy[832] D=nx3473 CLK=clk R=rst
Xix3474 mux21_ni $PINS Y=nx3473 A0=camera_module_cache_ram_34__0 A1=nx34172
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__0 dffr $PINS Q=camera_module_cache_ram_50__0
+ QB=#dummy[833] D=nx3463 CLK=clk R=rst
Xix3464 mux21_ni $PINS Y=nx3463 A0=camera_module_cache_ram_50__0 A1=nx34174
+ S0=nx34982
Xix27880 aoi22 $PINS Y=nx27879 A0=camera_module_cache_ram_66__0 A1=nx35982
+ B0=camera_module_cache_ram_82__0 B1=nx36022
Xcamera_module_cache_reg_ram_66__0 dffr $PINS Q=camera_module_cache_ram_66__0
+ QB=#dummy[834] D=nx3453 CLK=clk R=rst
Xix3454 mux21_ni $PINS Y=nx3453 A0=camera_module_cache_ram_66__0 A1=nx34174
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__0 dffr $PINS Q=camera_module_cache_ram_82__0
+ QB=#dummy[835] D=nx3443 CLK=clk R=rst
Xix3444 mux21_ni $PINS Y=nx3443 A0=camera_module_cache_ram_82__0 A1=nx34174
+ S0=nx34974
Xix27888 aoi22 $PINS Y=nx27887 A0=camera_module_cache_ram_114__0 A1=nx36062
+ B0=camera_module_cache_ram_98__0 B1=nx36102
Xcamera_module_cache_reg_ram_114__0 dffr $PINS Q=camera_module_cache_ram_114__0
+ QB=#dummy[836] D=nx3423 CLK=clk R=rst
Xix3424 mux21_ni $PINS Y=nx3423 A0=camera_module_cache_ram_114__0 A1=nx34174
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__0 dffr $PINS Q=camera_module_cache_ram_98__0
+ QB=#dummy[837] D=nx3433 CLK=clk R=rst
Xix3434 mux21_ni $PINS Y=nx3433 A0=camera_module_cache_ram_98__0 A1=nx34174
+ S0=nx34970
Xix5207 nand04 $PINS Y=nx5206 A0=nx27896 A1=nx27904 A2=nx27912 A3=nx27920
Xix27897 aoi22 $PINS Y=nx27896 A0=camera_module_cache_ram_130__0 A1=nx36142
+ B0=camera_module_cache_ram_146__0 B1=nx36182
Xcamera_module_cache_reg_ram_130__0 dffr $PINS Q=camera_module_cache_ram_130__0
+ QB=#dummy[838] D=nx3413 CLK=clk R=rst
Xix3414 mux21_ni $PINS Y=nx3413 A0=camera_module_cache_ram_130__0 A1=nx34174
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__0 dffr $PINS Q=camera_module_cache_ram_146__0
+ QB=#dummy[839] D=nx3403 CLK=clk R=rst
Xix3404 mux21_ni $PINS Y=nx3403 A0=camera_module_cache_ram_146__0 A1=nx34174
+ S0=nx34958
Xix27905 aoi22 $PINS Y=nx27904 A0=camera_module_cache_ram_178__0 A1=nx36222
+ B0=camera_module_cache_ram_162__0 B1=nx36262
Xcamera_module_cache_reg_ram_178__0 dffr $PINS Q=camera_module_cache_ram_178__0
+ QB=#dummy[840] D=nx3383 CLK=clk R=rst
Xix3384 mux21_ni $PINS Y=nx3383 A0=camera_module_cache_ram_178__0 A1=nx34176
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__0 dffr $PINS Q=camera_module_cache_ram_162__0
+ QB=#dummy[841] D=nx3393 CLK=clk R=rst
Xix3394 mux21_ni $PINS Y=nx3393 A0=camera_module_cache_ram_162__0 A1=nx34176
+ S0=nx34954
Xix27913 aoi22 $PINS Y=nx27912 A0=camera_module_cache_ram_194__0 A1=nx36302
+ B0=camera_module_cache_ram_210__0 B1=nx36342
Xcamera_module_cache_reg_ram_194__0 dffr $PINS Q=camera_module_cache_ram_194__0
+ QB=#dummy[842] D=nx3373 CLK=clk R=rst
Xix3374 mux21_ni $PINS Y=nx3373 A0=camera_module_cache_ram_194__0 A1=nx34176
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__0 dffr $PINS Q=camera_module_cache_ram_210__0
+ QB=#dummy[843] D=nx3363 CLK=clk R=rst
Xix3364 mux21_ni $PINS Y=nx3363 A0=camera_module_cache_ram_210__0 A1=nx34176
+ S0=nx34942
Xix27921 aoi22 $PINS Y=nx27920 A0=camera_module_cache_ram_226__0 A1=nx36382
+ B0=camera_module_cache_ram_242__0 B1=nx36422
Xcamera_module_cache_reg_ram_226__0 dffr $PINS Q=camera_module_cache_ram_226__0
+ QB=#dummy[844] D=nx3353 CLK=clk R=rst
Xix3354 mux21_ni $PINS Y=nx3353 A0=camera_module_cache_ram_226__0 A1=nx34176
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__0 dffr $PINS Q=camera_module_cache_ram_242__0
+ QB=#dummy[845] D=nx3343 CLK=clk R=rst
Xix3344 mux21_ni $PINS Y=nx3343 A0=camera_module_cache_ram_242__0 A1=nx34176
+ S0=nx34934
Xix27929 oai21 $PINS Y=nx27928 A0=nx5056 A1=nx4914 B0=nx36460
Xix5057 nand04 $PINS Y=nx5056 A0=nx27931 A1=nx27939 A2=nx27947 A3=nx27955
Xix27932 aoi22 $PINS Y=nx27931 A0=camera_module_cache_ram_3__0 A1=nx35822
+ B0=camera_module_cache_ram_19__0 B1=nx35862
Xcamera_module_cache_reg_ram_3__0 dffr $PINS Q=camera_module_cache_ram_3__0
+ QB=#dummy[846] D=nx3333 CLK=clk R=rst
Xix3334 mux21_ni $PINS Y=nx3333 A0=camera_module_cache_ram_3__0 A1=nx34176
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__0 dffr $PINS Q=camera_module_cache_ram_19__0
+ QB=#dummy[847] D=nx3323 CLK=clk R=rst
Xix3324 mux21_ni $PINS Y=nx3323 A0=camera_module_cache_ram_19__0 A1=nx34178
+ S0=nx34920
Xix27940 aoi22 $PINS Y=nx27939 A0=camera_module_cache_ram_35__0 A1=nx35902
+ B0=camera_module_cache_ram_51__0 B1=nx35942
Xcamera_module_cache_reg_ram_35__0 dffr $PINS Q=camera_module_cache_ram_35__0
+ QB=#dummy[848] D=nx3313 CLK=clk R=rst
Xix3314 mux21_ni $PINS Y=nx3313 A0=camera_module_cache_ram_35__0 A1=nx34178
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__0 dffr $PINS Q=camera_module_cache_ram_51__0
+ QB=#dummy[849] D=nx3303 CLK=clk R=rst
Xix3304 mux21_ni $PINS Y=nx3303 A0=camera_module_cache_ram_51__0 A1=nx34178
+ S0=nx34912
Xix27948 aoi22 $PINS Y=nx27947 A0=camera_module_cache_ram_67__0 A1=nx35982
+ B0=camera_module_cache_ram_83__0 B1=nx36022
Xcamera_module_cache_reg_ram_67__0 dffr $PINS Q=camera_module_cache_ram_67__0
+ QB=#dummy[850] D=nx3293 CLK=clk R=rst
Xix3294 mux21_ni $PINS Y=nx3293 A0=camera_module_cache_ram_67__0 A1=nx34178
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__0 dffr $PINS Q=camera_module_cache_ram_83__0
+ QB=#dummy[851] D=nx3283 CLK=clk R=rst
Xix3284 mux21_ni $PINS Y=nx3283 A0=camera_module_cache_ram_83__0 A1=nx34178
+ S0=nx34904
Xix27956 aoi22 $PINS Y=nx27955 A0=camera_module_cache_ram_115__0 A1=nx36062
+ B0=camera_module_cache_ram_99__0 B1=nx36102
Xcamera_module_cache_reg_ram_115__0 dffr $PINS Q=camera_module_cache_ram_115__0
+ QB=#dummy[852] D=nx3263 CLK=clk R=rst
Xix3264 mux21_ni $PINS Y=nx3263 A0=camera_module_cache_ram_115__0 A1=nx34178
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__0 dffr $PINS Q=camera_module_cache_ram_99__0
+ QB=#dummy[853] D=nx3273 CLK=clk R=rst
Xix3274 mux21_ni $PINS Y=nx3273 A0=camera_module_cache_ram_99__0 A1=nx34178
+ S0=nx34900
Xix4915 nand04 $PINS Y=nx4914 A0=nx27964 A1=nx27972 A2=nx27980 A3=nx27988
Xix27965 aoi22 $PINS Y=nx27964 A0=camera_module_cache_ram_131__0 A1=nx36142
+ B0=camera_module_cache_ram_147__0 B1=nx36182
Xcamera_module_cache_reg_ram_131__0 dffr $PINS Q=camera_module_cache_ram_131__0
+ QB=#dummy[854] D=nx3253 CLK=clk R=rst
Xix3254 mux21_ni $PINS Y=nx3253 A0=camera_module_cache_ram_131__0 A1=nx34180
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__0 dffr $PINS Q=camera_module_cache_ram_147__0
+ QB=#dummy[855] D=nx3243 CLK=clk R=rst
Xix3244 mux21_ni $PINS Y=nx3243 A0=camera_module_cache_ram_147__0 A1=nx34180
+ S0=nx34888
Xix27973 aoi22 $PINS Y=nx27972 A0=camera_module_cache_ram_179__0 A1=nx36222
+ B0=camera_module_cache_ram_163__0 B1=nx36262
Xcamera_module_cache_reg_ram_179__0 dffr $PINS Q=camera_module_cache_ram_179__0
+ QB=#dummy[856] D=nx3223 CLK=clk R=rst
Xix3224 mux21_ni $PINS Y=nx3223 A0=camera_module_cache_ram_179__0 A1=nx34180
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__0 dffr $PINS Q=camera_module_cache_ram_163__0
+ QB=#dummy[857] D=nx3233 CLK=clk R=rst
Xix3234 mux21_ni $PINS Y=nx3233 A0=camera_module_cache_ram_163__0 A1=nx34180
+ S0=nx34884
Xix27981 aoi22 $PINS Y=nx27980 A0=camera_module_cache_ram_195__0 A1=nx36302
+ B0=camera_module_cache_ram_211__0 B1=nx36342
Xcamera_module_cache_reg_ram_195__0 dffr $PINS Q=camera_module_cache_ram_195__0
+ QB=#dummy[858] D=nx3213 CLK=clk R=rst
Xix3214 mux21_ni $PINS Y=nx3213 A0=camera_module_cache_ram_195__0 A1=nx34180
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__0 dffr $PINS Q=camera_module_cache_ram_211__0
+ QB=#dummy[859] D=nx3203 CLK=clk R=rst
Xix3204 mux21_ni $PINS Y=nx3203 A0=camera_module_cache_ram_211__0 A1=nx34180
+ S0=nx34872
Xix27989 aoi22 $PINS Y=nx27988 A0=camera_module_cache_ram_227__0 A1=nx36382
+ B0=camera_module_cache_ram_243__0 B1=nx36422
Xcamera_module_cache_reg_ram_227__0 dffr $PINS Q=camera_module_cache_ram_227__0
+ QB=#dummy[860] D=nx3193 CLK=clk R=rst
Xix3194 mux21_ni $PINS Y=nx3193 A0=camera_module_cache_ram_227__0 A1=nx34180
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__0 dffr $PINS Q=camera_module_cache_ram_243__0
+ QB=#dummy[861] D=nx3183 CLK=clk R=rst
Xix3184 mux21_ni $PINS Y=nx3183 A0=camera_module_cache_ram_243__0 A1=nx34182
+ S0=nx34864
Xix4769 nand04 $PINS Y=nx4768 A0=nx27997 A1=nx28065 A2=nx28133 A3=nx28201
Xix27998 oai21 $PINS Y=nx27997 A0=nx4758 A1=nx4616 B0=nx36464
Xix4759 nand04 $PINS Y=nx4758 A0=nx28000 A1=nx28008 A2=nx28016 A3=nx28024
Xix28001 aoi22 $PINS Y=nx28000 A0=camera_module_cache_ram_4__0 A1=nx35824
+ B0=camera_module_cache_ram_20__0 B1=nx35864
Xcamera_module_cache_reg_ram_4__0 dffr $PINS Q=camera_module_cache_ram_4__0
+ QB=#dummy[862] D=nx3173 CLK=clk R=rst
Xix3174 mux21_ni $PINS Y=nx3173 A0=camera_module_cache_ram_4__0 A1=nx34182
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__0 dffr $PINS Q=camera_module_cache_ram_20__0
+ QB=#dummy[863] D=nx3163 CLK=clk R=rst
Xix3164 mux21_ni $PINS Y=nx3163 A0=camera_module_cache_ram_20__0 A1=nx34182
+ S0=nx34850
Xix28009 aoi22 $PINS Y=nx28008 A0=camera_module_cache_ram_36__0 A1=nx35904
+ B0=camera_module_cache_ram_52__0 B1=nx35944
Xcamera_module_cache_reg_ram_36__0 dffr $PINS Q=camera_module_cache_ram_36__0
+ QB=#dummy[864] D=nx3153 CLK=clk R=rst
Xix3154 mux21_ni $PINS Y=nx3153 A0=camera_module_cache_ram_36__0 A1=nx34182
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__0 dffr $PINS Q=camera_module_cache_ram_52__0
+ QB=#dummy[865] D=nx3143 CLK=clk R=rst
Xix3144 mux21_ni $PINS Y=nx3143 A0=camera_module_cache_ram_52__0 A1=nx34182
+ S0=nx34842
Xix28017 aoi22 $PINS Y=nx28016 A0=camera_module_cache_ram_68__0 A1=nx35984
+ B0=camera_module_cache_ram_84__0 B1=nx36024
Xcamera_module_cache_reg_ram_68__0 dffr $PINS Q=camera_module_cache_ram_68__0
+ QB=#dummy[866] D=nx3133 CLK=clk R=rst
Xix3134 mux21_ni $PINS Y=nx3133 A0=camera_module_cache_ram_68__0 A1=nx34182
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__0 dffr $PINS Q=camera_module_cache_ram_84__0
+ QB=#dummy[867] D=nx3123 CLK=clk R=rst
Xix3124 mux21_ni $PINS Y=nx3123 A0=camera_module_cache_ram_84__0 A1=nx34182
+ S0=nx34834
Xix28025 aoi22 $PINS Y=nx28024 A0=camera_module_cache_ram_116__0 A1=nx36064
+ B0=camera_module_cache_ram_100__0 B1=nx36104
Xcamera_module_cache_reg_ram_116__0 dffr $PINS Q=camera_module_cache_ram_116__0
+ QB=#dummy[868] D=nx3103 CLK=clk R=rst
Xix3104 mux21_ni $PINS Y=nx3103 A0=camera_module_cache_ram_116__0 A1=nx34184
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__0 dffr $PINS Q=camera_module_cache_ram_100__0
+ QB=#dummy[869] D=nx3113 CLK=clk R=rst
Xix3114 mux21_ni $PINS Y=nx3113 A0=camera_module_cache_ram_100__0 A1=nx34184
+ S0=nx34830
Xix4617 nand04 $PINS Y=nx4616 A0=nx28033 A1=nx28041 A2=nx28049 A3=nx28057
Xix28034 aoi22 $PINS Y=nx28033 A0=camera_module_cache_ram_132__0 A1=nx36144
+ B0=camera_module_cache_ram_148__0 B1=nx36184
Xcamera_module_cache_reg_ram_132__0 dffr $PINS Q=camera_module_cache_ram_132__0
+ QB=#dummy[870] D=nx3093 CLK=clk R=rst
Xix3094 mux21_ni $PINS Y=nx3093 A0=camera_module_cache_ram_132__0 A1=nx34184
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__0 dffr $PINS Q=camera_module_cache_ram_148__0
+ QB=#dummy[871] D=nx3083 CLK=clk R=rst
Xix3084 mux21_ni $PINS Y=nx3083 A0=camera_module_cache_ram_148__0 A1=nx34184
+ S0=nx34818
Xix28042 aoi22 $PINS Y=nx28041 A0=camera_module_cache_ram_180__0 A1=nx36224
+ B0=camera_module_cache_ram_164__0 B1=nx36264
Xcamera_module_cache_reg_ram_180__0 dffr $PINS Q=camera_module_cache_ram_180__0
+ QB=#dummy[872] D=nx3063 CLK=clk R=rst
Xix3064 mux21_ni $PINS Y=nx3063 A0=camera_module_cache_ram_180__0 A1=nx34184
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__0 dffr $PINS Q=camera_module_cache_ram_164__0
+ QB=#dummy[873] D=nx3073 CLK=clk R=rst
Xix3074 mux21_ni $PINS Y=nx3073 A0=camera_module_cache_ram_164__0 A1=nx34184
+ S0=nx34814
Xix28050 aoi22 $PINS Y=nx28049 A0=camera_module_cache_ram_196__0 A1=nx36304
+ B0=camera_module_cache_ram_212__0 B1=nx36344
Xcamera_module_cache_reg_ram_196__0 dffr $PINS Q=camera_module_cache_ram_196__0
+ QB=#dummy[874] D=nx3053 CLK=clk R=rst
Xix3054 mux21_ni $PINS Y=nx3053 A0=camera_module_cache_ram_196__0 A1=nx34184
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__0 dffr $PINS Q=camera_module_cache_ram_212__0
+ QB=#dummy[875] D=nx3043 CLK=clk R=rst
Xix3044 mux21_ni $PINS Y=nx3043 A0=camera_module_cache_ram_212__0 A1=nx34186
+ S0=nx34802
Xix28058 aoi22 $PINS Y=nx28057 A0=camera_module_cache_ram_228__0 A1=nx36384
+ B0=camera_module_cache_ram_244__0 B1=nx36424
Xcamera_module_cache_reg_ram_228__0 dffr $PINS Q=camera_module_cache_ram_228__0
+ QB=#dummy[876] D=nx3033 CLK=clk R=rst
Xix3034 mux21_ni $PINS Y=nx3033 A0=camera_module_cache_ram_228__0 A1=nx34186
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__0 dffr $PINS Q=camera_module_cache_ram_244__0
+ QB=#dummy[877] D=nx3023 CLK=clk R=rst
Xix3024 mux21_ni $PINS Y=nx3023 A0=camera_module_cache_ram_244__0 A1=nx34186
+ S0=nx34794
Xix28066 oai21 $PINS Y=nx28065 A0=nx4466 A1=nx4324 B0=nx36468
Xix4467 nand04 $PINS Y=nx4466 A0=nx28068 A1=nx28076 A2=nx28084 A3=nx28092
Xix28069 aoi22 $PINS Y=nx28068 A0=camera_module_cache_ram_5__0 A1=nx35824
+ B0=camera_module_cache_ram_21__0 B1=nx35864
Xcamera_module_cache_reg_ram_5__0 dffr $PINS Q=camera_module_cache_ram_5__0
+ QB=#dummy[878] D=nx3013 CLK=clk R=rst
Xix3014 mux21_ni $PINS Y=nx3013 A0=camera_module_cache_ram_5__0 A1=nx34186
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__0 dffr $PINS Q=camera_module_cache_ram_21__0
+ QB=#dummy[879] D=nx3003 CLK=clk R=rst
Xix3004 mux21_ni $PINS Y=nx3003 A0=camera_module_cache_ram_21__0 A1=nx34186
+ S0=nx34780
Xix28077 aoi22 $PINS Y=nx28076 A0=camera_module_cache_ram_37__0 A1=nx35904
+ B0=camera_module_cache_ram_53__0 B1=nx35944
Xcamera_module_cache_reg_ram_37__0 dffr $PINS Q=camera_module_cache_ram_37__0
+ QB=#dummy[880] D=nx2993 CLK=clk R=rst
Xix2994 mux21_ni $PINS Y=nx2993 A0=camera_module_cache_ram_37__0 A1=nx34186
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__0 dffr $PINS Q=camera_module_cache_ram_53__0
+ QB=#dummy[881] D=nx2983 CLK=clk R=rst
Xix2984 mux21_ni $PINS Y=nx2983 A0=camera_module_cache_ram_53__0 A1=nx34186
+ S0=nx34772
Xix28085 aoi22 $PINS Y=nx28084 A0=camera_module_cache_ram_69__0 A1=nx35984
+ B0=camera_module_cache_ram_85__0 B1=nx36024
Xcamera_module_cache_reg_ram_69__0 dffr $PINS Q=camera_module_cache_ram_69__0
+ QB=#dummy[882] D=nx2973 CLK=clk R=rst
Xix2974 mux21_ni $PINS Y=nx2973 A0=camera_module_cache_ram_69__0 A1=nx34188
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__0 dffr $PINS Q=camera_module_cache_ram_85__0
+ QB=#dummy[883] D=nx2963 CLK=clk R=rst
Xix2964 mux21_ni $PINS Y=nx2963 A0=camera_module_cache_ram_85__0 A1=nx34188
+ S0=nx34764
Xix28093 aoi22 $PINS Y=nx28092 A0=camera_module_cache_ram_117__0 A1=nx36064
+ B0=camera_module_cache_ram_101__0 B1=nx36104
Xcamera_module_cache_reg_ram_117__0 dffr $PINS Q=camera_module_cache_ram_117__0
+ QB=#dummy[884] D=nx2943 CLK=clk R=rst
Xix2944 mux21_ni $PINS Y=nx2943 A0=camera_module_cache_ram_117__0 A1=nx34188
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__0 dffr $PINS Q=camera_module_cache_ram_101__0
+ QB=#dummy[885] D=nx2953 CLK=clk R=rst
Xix2954 mux21_ni $PINS Y=nx2953 A0=camera_module_cache_ram_101__0 A1=nx34188
+ S0=nx34760
Xix4325 nand04 $PINS Y=nx4324 A0=nx28101 A1=nx28109 A2=nx28117 A3=nx28125
Xix28102 aoi22 $PINS Y=nx28101 A0=camera_module_cache_ram_133__0 A1=nx36144
+ B0=camera_module_cache_ram_149__0 B1=nx36184
Xcamera_module_cache_reg_ram_133__0 dffr $PINS Q=camera_module_cache_ram_133__0
+ QB=#dummy[886] D=nx2933 CLK=clk R=rst
Xix2934 mux21_ni $PINS Y=nx2933 A0=camera_module_cache_ram_133__0 A1=nx34188
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__0 dffr $PINS Q=camera_module_cache_ram_149__0
+ QB=#dummy[887] D=nx2923 CLK=clk R=rst
Xix2924 mux21_ni $PINS Y=nx2923 A0=camera_module_cache_ram_149__0 A1=nx34188
+ S0=nx34748
Xix28110 aoi22 $PINS Y=nx28109 A0=camera_module_cache_ram_181__0 A1=nx36224
+ B0=camera_module_cache_ram_165__0 B1=nx36264
Xcamera_module_cache_reg_ram_181__0 dffr $PINS Q=camera_module_cache_ram_181__0
+ QB=#dummy[888] D=nx2903 CLK=clk R=rst
Xix2904 mux21_ni $PINS Y=nx2903 A0=camera_module_cache_ram_181__0 A1=nx34188
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__0 dffr $PINS Q=camera_module_cache_ram_165__0
+ QB=#dummy[889] D=nx2913 CLK=clk R=rst
Xix2914 mux21_ni $PINS Y=nx2913 A0=camera_module_cache_ram_165__0 A1=nx34190
+ S0=nx34744
Xix28118 aoi22 $PINS Y=nx28117 A0=camera_module_cache_ram_197__0 A1=nx36304
+ B0=camera_module_cache_ram_213__0 B1=nx36344
Xcamera_module_cache_reg_ram_197__0 dffr $PINS Q=camera_module_cache_ram_197__0
+ QB=#dummy[890] D=nx2893 CLK=clk R=rst
Xix2894 mux21_ni $PINS Y=nx2893 A0=camera_module_cache_ram_197__0 A1=nx34190
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__0 dffr $PINS Q=camera_module_cache_ram_213__0
+ QB=#dummy[891] D=nx2883 CLK=clk R=rst
Xix2884 mux21_ni $PINS Y=nx2883 A0=camera_module_cache_ram_213__0 A1=nx34190
+ S0=nx34732
Xix28126 aoi22 $PINS Y=nx28125 A0=camera_module_cache_ram_229__0 A1=nx36384
+ B0=camera_module_cache_ram_245__0 B1=nx36424
Xcamera_module_cache_reg_ram_229__0 dffr $PINS Q=camera_module_cache_ram_229__0
+ QB=#dummy[892] D=nx2873 CLK=clk R=rst
Xix2874 mux21_ni $PINS Y=nx2873 A0=camera_module_cache_ram_229__0 A1=nx34190
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__0 dffr $PINS Q=camera_module_cache_ram_245__0
+ QB=#dummy[893] D=nx2863 CLK=clk R=rst
Xix2864 mux21_ni $PINS Y=nx2863 A0=camera_module_cache_ram_245__0 A1=nx34190
+ S0=nx34724
Xix28134 oai21 $PINS Y=nx28133 A0=nx4172 A1=nx4030 B0=nx36472
Xix4173 nand04 $PINS Y=nx4172 A0=nx28136 A1=nx28144 A2=nx28152 A3=nx28160
Xix28137 aoi22 $PINS Y=nx28136 A0=camera_module_cache_ram_6__0 A1=nx35824
+ B0=camera_module_cache_ram_22__0 B1=nx35864
Xcamera_module_cache_reg_ram_6__0 dffr $PINS Q=camera_module_cache_ram_6__0
+ QB=#dummy[894] D=nx2853 CLK=clk R=rst
Xix2854 mux21_ni $PINS Y=nx2853 A0=camera_module_cache_ram_6__0 A1=nx34190
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__0 dffr $PINS Q=camera_module_cache_ram_22__0
+ QB=#dummy[895] D=nx2843 CLK=clk R=rst
Xix2844 mux21_ni $PINS Y=nx2843 A0=camera_module_cache_ram_22__0 A1=nx34190
+ S0=nx34710
Xix28145 aoi22 $PINS Y=nx28144 A0=camera_module_cache_ram_38__0 A1=nx35904
+ B0=camera_module_cache_ram_54__0 B1=nx35944
Xcamera_module_cache_reg_ram_38__0 dffr $PINS Q=camera_module_cache_ram_38__0
+ QB=#dummy[896] D=nx2833 CLK=clk R=rst
Xix2834 mux21_ni $PINS Y=nx2833 A0=camera_module_cache_ram_38__0 A1=nx34192
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__0 dffr $PINS Q=camera_module_cache_ram_54__0
+ QB=#dummy[897] D=nx2823 CLK=clk R=rst
Xix2824 mux21_ni $PINS Y=nx2823 A0=camera_module_cache_ram_54__0 A1=nx34192
+ S0=nx34702
Xix28153 aoi22 $PINS Y=nx28152 A0=camera_module_cache_ram_70__0 A1=nx35984
+ B0=camera_module_cache_ram_86__0 B1=nx36024
Xcamera_module_cache_reg_ram_70__0 dffr $PINS Q=camera_module_cache_ram_70__0
+ QB=#dummy[898] D=nx2813 CLK=clk R=rst
Xix2814 mux21_ni $PINS Y=nx2813 A0=camera_module_cache_ram_70__0 A1=nx34192
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__0 dffr $PINS Q=camera_module_cache_ram_86__0
+ QB=#dummy[899] D=nx2803 CLK=clk R=rst
Xix2804 mux21_ni $PINS Y=nx2803 A0=camera_module_cache_ram_86__0 A1=nx34192
+ S0=nx34694
Xix28161 aoi22 $PINS Y=nx28160 A0=camera_module_cache_ram_118__0 A1=nx36064
+ B0=camera_module_cache_ram_102__0 B1=nx36104
Xcamera_module_cache_reg_ram_118__0 dffr $PINS Q=camera_module_cache_ram_118__0
+ QB=#dummy[900] D=nx2783 CLK=clk R=rst
Xix2784 mux21_ni $PINS Y=nx2783 A0=camera_module_cache_ram_118__0 A1=nx34192
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__0 dffr $PINS Q=camera_module_cache_ram_102__0
+ QB=#dummy[901] D=nx2793 CLK=clk R=rst
Xix2794 mux21_ni $PINS Y=nx2793 A0=camera_module_cache_ram_102__0 A1=nx34192
+ S0=nx34690
Xix4031 nand04 $PINS Y=nx4030 A0=nx28169 A1=nx28177 A2=nx28185 A3=nx28193
Xix28170 aoi22 $PINS Y=nx28169 A0=camera_module_cache_ram_134__0 A1=nx36144
+ B0=camera_module_cache_ram_150__0 B1=nx36184
Xcamera_module_cache_reg_ram_134__0 dffr $PINS Q=camera_module_cache_ram_134__0
+ QB=#dummy[902] D=nx2773 CLK=clk R=rst
Xix2774 mux21_ni $PINS Y=nx2773 A0=camera_module_cache_ram_134__0 A1=nx34192
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__0 dffr $PINS Q=camera_module_cache_ram_150__0
+ QB=#dummy[903] D=nx2763 CLK=clk R=rst
Xix2764 mux21_ni $PINS Y=nx2763 A0=camera_module_cache_ram_150__0 A1=nx34194
+ S0=nx34678
Xix28178 aoi22 $PINS Y=nx28177 A0=camera_module_cache_ram_182__0 A1=nx36224
+ B0=camera_module_cache_ram_166__0 B1=nx36264
Xcamera_module_cache_reg_ram_182__0 dffr $PINS Q=camera_module_cache_ram_182__0
+ QB=#dummy[904] D=nx2743 CLK=clk R=rst
Xix2744 mux21_ni $PINS Y=nx2743 A0=camera_module_cache_ram_182__0 A1=nx34194
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__0 dffr $PINS Q=camera_module_cache_ram_166__0
+ QB=#dummy[905] D=nx2753 CLK=clk R=rst
Xix2754 mux21_ni $PINS Y=nx2753 A0=camera_module_cache_ram_166__0 A1=nx34194
+ S0=nx34674
Xix28186 aoi22 $PINS Y=nx28185 A0=camera_module_cache_ram_198__0 A1=nx36304
+ B0=camera_module_cache_ram_214__0 B1=nx36344
Xcamera_module_cache_reg_ram_198__0 dffr $PINS Q=camera_module_cache_ram_198__0
+ QB=#dummy[906] D=nx2733 CLK=clk R=rst
Xix2734 mux21_ni $PINS Y=nx2733 A0=camera_module_cache_ram_198__0 A1=nx34194
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__0 dffr $PINS Q=camera_module_cache_ram_214__0
+ QB=#dummy[907] D=nx2723 CLK=clk R=rst
Xix2724 mux21_ni $PINS Y=nx2723 A0=camera_module_cache_ram_214__0 A1=nx34194
+ S0=nx34662
Xix28194 aoi22 $PINS Y=nx28193 A0=camera_module_cache_ram_230__0 A1=nx36384
+ B0=camera_module_cache_ram_246__0 B1=nx36424
Xcamera_module_cache_reg_ram_230__0 dffr $PINS Q=camera_module_cache_ram_230__0
+ QB=#dummy[908] D=nx2713 CLK=clk R=rst
Xix2714 mux21_ni $PINS Y=nx2713 A0=camera_module_cache_ram_230__0 A1=nx34194
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__0 dffr $PINS Q=camera_module_cache_ram_246__0
+ QB=#dummy[909] D=nx2703 CLK=clk R=rst
Xix2704 mux21_ni $PINS Y=nx2703 A0=camera_module_cache_ram_246__0 A1=nx34194
+ S0=nx34654
Xix28202 oai21 $PINS Y=nx28201 A0=nx3880 A1=nx3738 B0=nx36476
Xix3881 nand04 $PINS Y=nx3880 A0=nx28204 A1=nx28212 A2=nx28220 A3=nx28228
Xix28205 aoi22 $PINS Y=nx28204 A0=camera_module_cache_ram_7__0 A1=nx35824
+ B0=camera_module_cache_ram_23__0 B1=nx35864
Xcamera_module_cache_reg_ram_7__0 dffr $PINS Q=camera_module_cache_ram_7__0
+ QB=#dummy[910] D=nx2693 CLK=clk R=rst
Xix2694 mux21_ni $PINS Y=nx2693 A0=camera_module_cache_ram_7__0 A1=nx34196
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__0 dffr $PINS Q=camera_module_cache_ram_23__0
+ QB=#dummy[911] D=nx2683 CLK=clk R=rst
Xix2684 mux21_ni $PINS Y=nx2683 A0=camera_module_cache_ram_23__0 A1=nx34196
+ S0=nx34640
Xix28213 aoi22 $PINS Y=nx28212 A0=camera_module_cache_ram_39__0 A1=nx35904
+ B0=camera_module_cache_ram_55__0 B1=nx35944
Xcamera_module_cache_reg_ram_39__0 dffr $PINS Q=camera_module_cache_ram_39__0
+ QB=#dummy[912] D=nx2673 CLK=clk R=rst
Xix2674 mux21_ni $PINS Y=nx2673 A0=camera_module_cache_ram_39__0 A1=nx34196
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__0 dffr $PINS Q=camera_module_cache_ram_55__0
+ QB=#dummy[913] D=nx2663 CLK=clk R=rst
Xix2664 mux21_ni $PINS Y=nx2663 A0=camera_module_cache_ram_55__0 A1=nx34196
+ S0=nx34632
Xix28221 aoi22 $PINS Y=nx28220 A0=camera_module_cache_ram_71__0 A1=nx35984
+ B0=camera_module_cache_ram_87__0 B1=nx36024
Xcamera_module_cache_reg_ram_71__0 dffr $PINS Q=camera_module_cache_ram_71__0
+ QB=#dummy[914] D=nx2653 CLK=clk R=rst
Xix2654 mux21_ni $PINS Y=nx2653 A0=camera_module_cache_ram_71__0 A1=nx34196
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__0 dffr $PINS Q=camera_module_cache_ram_87__0
+ QB=#dummy[915] D=nx2643 CLK=clk R=rst
Xix2644 mux21_ni $PINS Y=nx2643 A0=camera_module_cache_ram_87__0 A1=nx34196
+ S0=nx34624
Xix28229 aoi22 $PINS Y=nx28228 A0=camera_module_cache_ram_119__0 A1=nx36064
+ B0=camera_module_cache_ram_103__0 B1=nx36104
Xcamera_module_cache_reg_ram_119__0 dffr $PINS Q=camera_module_cache_ram_119__0
+ QB=#dummy[916] D=nx2623 CLK=clk R=rst
Xix2624 mux21_ni $PINS Y=nx2623 A0=camera_module_cache_ram_119__0 A1=nx34196
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__0 dffr $PINS Q=camera_module_cache_ram_103__0
+ QB=#dummy[917] D=nx2633 CLK=clk R=rst
Xix2634 mux21_ni $PINS Y=nx2633 A0=camera_module_cache_ram_103__0 A1=nx34198
+ S0=nx34620
Xix3739 nand04 $PINS Y=nx3738 A0=nx28237 A1=nx28245 A2=nx28253 A3=nx28261
Xix28238 aoi22 $PINS Y=nx28237 A0=camera_module_cache_ram_135__0 A1=nx36144
+ B0=camera_module_cache_ram_151__0 B1=nx36184
Xcamera_module_cache_reg_ram_135__0 dffr $PINS Q=camera_module_cache_ram_135__0
+ QB=#dummy[918] D=nx2613 CLK=clk R=rst
Xix2614 mux21_ni $PINS Y=nx2613 A0=camera_module_cache_ram_135__0 A1=nx34198
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__0 dffr $PINS Q=camera_module_cache_ram_151__0
+ QB=#dummy[919] D=nx2603 CLK=clk R=rst
Xix2604 mux21_ni $PINS Y=nx2603 A0=camera_module_cache_ram_151__0 A1=nx34198
+ S0=nx34608
Xix28246 aoi22 $PINS Y=nx28245 A0=camera_module_cache_ram_183__0 A1=nx36224
+ B0=camera_module_cache_ram_167__0 B1=nx36264
Xcamera_module_cache_reg_ram_183__0 dffr $PINS Q=camera_module_cache_ram_183__0
+ QB=#dummy[920] D=nx2583 CLK=clk R=rst
Xix2584 mux21_ni $PINS Y=nx2583 A0=camera_module_cache_ram_183__0 A1=nx34198
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__0 dffr $PINS Q=camera_module_cache_ram_167__0
+ QB=#dummy[921] D=nx2593 CLK=clk R=rst
Xix2594 mux21_ni $PINS Y=nx2593 A0=camera_module_cache_ram_167__0 A1=nx34198
+ S0=nx34604
Xix28254 aoi22 $PINS Y=nx28253 A0=camera_module_cache_ram_199__0 A1=nx36304
+ B0=camera_module_cache_ram_215__0 B1=nx36344
Xcamera_module_cache_reg_ram_199__0 dffr $PINS Q=camera_module_cache_ram_199__0
+ QB=#dummy[922] D=nx2573 CLK=clk R=rst
Xix2574 mux21_ni $PINS Y=nx2573 A0=camera_module_cache_ram_199__0 A1=nx34198
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__0 dffr $PINS Q=camera_module_cache_ram_215__0
+ QB=#dummy[923] D=nx2563 CLK=clk R=rst
Xix2564 mux21_ni $PINS Y=nx2563 A0=camera_module_cache_ram_215__0 A1=nx34198
+ S0=nx34592
Xix28262 aoi22 $PINS Y=nx28261 A0=camera_module_cache_ram_231__0 A1=nx36384
+ B0=camera_module_cache_ram_247__0 B1=nx36424
Xcamera_module_cache_reg_ram_231__0 dffr $PINS Q=camera_module_cache_ram_231__0
+ QB=#dummy[924] D=nx2553 CLK=clk R=rst
Xix2554 mux21_ni $PINS Y=nx2553 A0=camera_module_cache_ram_231__0 A1=nx34200
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__0 dffr $PINS Q=camera_module_cache_ram_247__0
+ QB=#dummy[925] D=nx2543 CLK=clk R=rst
Xix2544 mux21_ni $PINS Y=nx2543 A0=camera_module_cache_ram_247__0 A1=nx34200
+ S0=nx34584
Xix3589 nand04 $PINS Y=nx3588 A0=nx28270 A1=nx28338 A2=nx28406 A3=nx28474
Xix28271 oai21 $PINS Y=nx28270 A0=nx3578 A1=nx3436 B0=nx36480
Xix3579 nand04 $PINS Y=nx3578 A0=nx28273 A1=nx28281 A2=nx28289 A3=nx28297
Xix28274 aoi22 $PINS Y=nx28273 A0=camera_module_cache_ram_8__0 A1=nx35824
+ B0=camera_module_cache_ram_24__0 B1=nx35864
Xcamera_module_cache_reg_ram_8__0 dffr $PINS Q=camera_module_cache_ram_8__0
+ QB=#dummy[926] D=nx2533 CLK=clk R=rst
Xix2534 mux21_ni $PINS Y=nx2533 A0=camera_module_cache_ram_8__0 A1=nx34200
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__0 dffr $PINS Q=camera_module_cache_ram_24__0
+ QB=#dummy[927] D=nx2523 CLK=clk R=rst
Xix2524 mux21_ni $PINS Y=nx2523 A0=camera_module_cache_ram_24__0 A1=nx34200
+ S0=nx34570
Xix28282 aoi22 $PINS Y=nx28281 A0=camera_module_cache_ram_40__0 A1=nx35904
+ B0=camera_module_cache_ram_56__0 B1=nx35944
Xcamera_module_cache_reg_ram_40__0 dffr $PINS Q=camera_module_cache_ram_40__0
+ QB=#dummy[928] D=nx2513 CLK=clk R=rst
Xix2514 mux21_ni $PINS Y=nx2513 A0=camera_module_cache_ram_40__0 A1=nx34200
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__0 dffr $PINS Q=camera_module_cache_ram_56__0
+ QB=#dummy[929] D=nx2503 CLK=clk R=rst
Xix2504 mux21_ni $PINS Y=nx2503 A0=camera_module_cache_ram_56__0 A1=nx34200
+ S0=nx34562
Xix28290 aoi22 $PINS Y=nx28289 A0=camera_module_cache_ram_72__0 A1=nx35984
+ B0=camera_module_cache_ram_88__0 B1=nx36024
Xcamera_module_cache_reg_ram_72__0 dffr $PINS Q=camera_module_cache_ram_72__0
+ QB=#dummy[930] D=nx2493 CLK=clk R=rst
Xix2494 mux21_ni $PINS Y=nx2493 A0=camera_module_cache_ram_72__0 A1=nx34200
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__0 dffr $PINS Q=camera_module_cache_ram_88__0
+ QB=#dummy[931] D=nx2483 CLK=clk R=rst
Xix2484 mux21_ni $PINS Y=nx2483 A0=camera_module_cache_ram_88__0 A1=nx34202
+ S0=nx34554
Xix28298 aoi22 $PINS Y=nx28297 A0=camera_module_cache_ram_120__0 A1=nx36064
+ B0=camera_module_cache_ram_104__0 B1=nx36104
Xcamera_module_cache_reg_ram_120__0 dffr $PINS Q=camera_module_cache_ram_120__0
+ QB=#dummy[932] D=nx2463 CLK=clk R=rst
Xix2464 mux21_ni $PINS Y=nx2463 A0=camera_module_cache_ram_120__0 A1=nx34202
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__0 dffr $PINS Q=camera_module_cache_ram_104__0
+ QB=#dummy[933] D=nx2473 CLK=clk R=rst
Xix2474 mux21_ni $PINS Y=nx2473 A0=camera_module_cache_ram_104__0 A1=nx34202
+ S0=nx34550
Xix3437 nand04 $PINS Y=nx3436 A0=nx28306 A1=nx28314 A2=nx28322 A3=nx28330
Xix28307 aoi22 $PINS Y=nx28306 A0=camera_module_cache_ram_136__0 A1=nx36144
+ B0=camera_module_cache_ram_152__0 B1=nx36184
Xcamera_module_cache_reg_ram_136__0 dffr $PINS Q=camera_module_cache_ram_136__0
+ QB=#dummy[934] D=nx2453 CLK=clk R=rst
Xix2454 mux21_ni $PINS Y=nx2453 A0=camera_module_cache_ram_136__0 A1=nx34202
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__0 dffr $PINS Q=camera_module_cache_ram_152__0
+ QB=#dummy[935] D=nx2443 CLK=clk R=rst
Xix2444 mux21_ni $PINS Y=nx2443 A0=camera_module_cache_ram_152__0 A1=nx34202
+ S0=nx34538
Xix28315 aoi22 $PINS Y=nx28314 A0=camera_module_cache_ram_184__0 A1=nx36224
+ B0=camera_module_cache_ram_168__0 B1=nx36264
Xcamera_module_cache_reg_ram_184__0 dffr $PINS Q=camera_module_cache_ram_184__0
+ QB=#dummy[936] D=nx2423 CLK=clk R=rst
Xix2424 mux21_ni $PINS Y=nx2423 A0=camera_module_cache_ram_184__0 A1=nx34202
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__0 dffr $PINS Q=camera_module_cache_ram_168__0
+ QB=#dummy[937] D=nx2433 CLK=clk R=rst
Xix2434 mux21_ni $PINS Y=nx2433 A0=camera_module_cache_ram_168__0 A1=nx34202
+ S0=nx34534
Xix28323 aoi22 $PINS Y=nx28322 A0=camera_module_cache_ram_200__0 A1=nx36304
+ B0=camera_module_cache_ram_216__0 B1=nx36344
Xcamera_module_cache_reg_ram_200__0 dffr $PINS Q=camera_module_cache_ram_200__0
+ QB=#dummy[938] D=nx2413 CLK=clk R=rst
Xix2414 mux21_ni $PINS Y=nx2413 A0=camera_module_cache_ram_200__0 A1=nx34204
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__0 dffr $PINS Q=camera_module_cache_ram_216__0
+ QB=#dummy[939] D=nx2403 CLK=clk R=rst
Xix2404 mux21_ni $PINS Y=nx2403 A0=camera_module_cache_ram_216__0 A1=nx34204
+ S0=nx34522
Xix28331 aoi22 $PINS Y=nx28330 A0=camera_module_cache_ram_232__0 A1=nx36384
+ B0=camera_module_cache_ram_248__0 B1=nx36424
Xcamera_module_cache_reg_ram_232__0 dffr $PINS Q=camera_module_cache_ram_232__0
+ QB=#dummy[940] D=nx2393 CLK=clk R=rst
Xix2394 mux21_ni $PINS Y=nx2393 A0=camera_module_cache_ram_232__0 A1=nx34204
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__0 dffr $PINS Q=camera_module_cache_ram_248__0
+ QB=#dummy[941] D=nx2383 CLK=clk R=rst
Xix2384 mux21_ni $PINS Y=nx2383 A0=camera_module_cache_ram_248__0 A1=nx34204
+ S0=nx34514
Xix28339 oai21 $PINS Y=nx28338 A0=nx3286 A1=nx3144 B0=nx36484
Xix3287 nand04 $PINS Y=nx3286 A0=nx28341 A1=nx28349 A2=nx28357 A3=nx28365
Xix28342 aoi22 $PINS Y=nx28341 A0=camera_module_cache_ram_9__0 A1=nx35824
+ B0=camera_module_cache_ram_25__0 B1=nx35864
Xcamera_module_cache_reg_ram_9__0 dffr $PINS Q=camera_module_cache_ram_9__0
+ QB=#dummy[942] D=nx2373 CLK=clk R=rst
Xix2374 mux21_ni $PINS Y=nx2373 A0=camera_module_cache_ram_9__0 A1=nx34204
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__0 dffr $PINS Q=camera_module_cache_ram_25__0
+ QB=#dummy[943] D=nx2363 CLK=clk R=rst
Xix2364 mux21_ni $PINS Y=nx2363 A0=camera_module_cache_ram_25__0 A1=nx34204
+ S0=nx34500
Xix28350 aoi22 $PINS Y=nx28349 A0=camera_module_cache_ram_41__0 A1=nx35904
+ B0=camera_module_cache_ram_57__0 B1=nx35944
Xcamera_module_cache_reg_ram_41__0 dffr $PINS Q=camera_module_cache_ram_41__0
+ QB=#dummy[944] D=nx2353 CLK=clk R=rst
Xix2354 mux21_ni $PINS Y=nx2353 A0=camera_module_cache_ram_41__0 A1=nx34204
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__0 dffr $PINS Q=camera_module_cache_ram_57__0
+ QB=#dummy[945] D=nx2343 CLK=clk R=rst
Xix2344 mux21_ni $PINS Y=nx2343 A0=camera_module_cache_ram_57__0 A1=nx34206
+ S0=nx34492
Xix28358 aoi22 $PINS Y=nx28357 A0=camera_module_cache_ram_73__0 A1=nx35984
+ B0=camera_module_cache_ram_89__0 B1=nx36024
Xcamera_module_cache_reg_ram_73__0 dffr $PINS Q=camera_module_cache_ram_73__0
+ QB=#dummy[946] D=nx2333 CLK=clk R=rst
Xix2334 mux21_ni $PINS Y=nx2333 A0=camera_module_cache_ram_73__0 A1=nx34206
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__0 dffr $PINS Q=camera_module_cache_ram_89__0
+ QB=#dummy[947] D=nx2323 CLK=clk R=rst
Xix2324 mux21_ni $PINS Y=nx2323 A0=camera_module_cache_ram_89__0 A1=nx34206
+ S0=nx34484
Xix28366 aoi22 $PINS Y=nx28365 A0=camera_module_cache_ram_121__0 A1=nx36064
+ B0=camera_module_cache_ram_105__0 B1=nx36104
Xcamera_module_cache_reg_ram_121__0 dffr $PINS Q=camera_module_cache_ram_121__0
+ QB=#dummy[948] D=nx2303 CLK=clk R=rst
Xix2304 mux21_ni $PINS Y=nx2303 A0=camera_module_cache_ram_121__0 A1=nx34206
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__0 dffr $PINS Q=camera_module_cache_ram_105__0
+ QB=#dummy[949] D=nx2313 CLK=clk R=rst
Xix2314 mux21_ni $PINS Y=nx2313 A0=camera_module_cache_ram_105__0 A1=nx34206
+ S0=nx34480
Xix3145 nand04 $PINS Y=nx3144 A0=nx28374 A1=nx28382 A2=nx28390 A3=nx28398
Xix28375 aoi22 $PINS Y=nx28374 A0=camera_module_cache_ram_137__0 A1=nx36144
+ B0=camera_module_cache_ram_153__0 B1=nx36184
Xcamera_module_cache_reg_ram_137__0 dffr $PINS Q=camera_module_cache_ram_137__0
+ QB=#dummy[950] D=nx2293 CLK=clk R=rst
Xix2294 mux21_ni $PINS Y=nx2293 A0=camera_module_cache_ram_137__0 A1=nx34206
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__0 dffr $PINS Q=camera_module_cache_ram_153__0
+ QB=#dummy[951] D=nx2283 CLK=clk R=rst
Xix2284 mux21_ni $PINS Y=nx2283 A0=camera_module_cache_ram_153__0 A1=nx34206
+ S0=nx34468
Xix28383 aoi22 $PINS Y=nx28382 A0=camera_module_cache_ram_185__0 A1=nx36224
+ B0=camera_module_cache_ram_169__0 B1=nx36264
Xcamera_module_cache_reg_ram_185__0 dffr $PINS Q=camera_module_cache_ram_185__0
+ QB=#dummy[952] D=nx2263 CLK=clk R=rst
Xix2264 mux21_ni $PINS Y=nx2263 A0=camera_module_cache_ram_185__0 A1=nx34208
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__0 dffr $PINS Q=camera_module_cache_ram_169__0
+ QB=#dummy[953] D=nx2273 CLK=clk R=rst
Xix2274 mux21_ni $PINS Y=nx2273 A0=camera_module_cache_ram_169__0 A1=nx34208
+ S0=nx34464
Xix28391 aoi22 $PINS Y=nx28390 A0=camera_module_cache_ram_201__0 A1=nx36304
+ B0=camera_module_cache_ram_217__0 B1=nx36344
Xcamera_module_cache_reg_ram_201__0 dffr $PINS Q=camera_module_cache_ram_201__0
+ QB=#dummy[954] D=nx2253 CLK=clk R=rst
Xix2254 mux21_ni $PINS Y=nx2253 A0=camera_module_cache_ram_201__0 A1=nx34208
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__0 dffr $PINS Q=camera_module_cache_ram_217__0
+ QB=#dummy[955] D=nx2243 CLK=clk R=rst
Xix2244 mux21_ni $PINS Y=nx2243 A0=camera_module_cache_ram_217__0 A1=nx34208
+ S0=nx34452
Xix28399 aoi22 $PINS Y=nx28398 A0=camera_module_cache_ram_233__0 A1=nx36384
+ B0=camera_module_cache_ram_249__0 B1=nx36424
Xcamera_module_cache_reg_ram_233__0 dffr $PINS Q=camera_module_cache_ram_233__0
+ QB=#dummy[956] D=nx2233 CLK=clk R=rst
Xix2234 mux21_ni $PINS Y=nx2233 A0=camera_module_cache_ram_233__0 A1=nx34208
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__0 dffr $PINS Q=camera_module_cache_ram_249__0
+ QB=#dummy[957] D=nx2223 CLK=clk R=rst
Xix2224 mux21_ni $PINS Y=nx2223 A0=camera_module_cache_ram_249__0 A1=nx34208
+ S0=nx34444
Xix28407 oai21 $PINS Y=nx28406 A0=nx2992 A1=nx2850 B0=nx36488
Xix2993 nand04 $PINS Y=nx2992 A0=nx28409 A1=nx28417 A2=nx28425 A3=nx28433
Xix28410 aoi22 $PINS Y=nx28409 A0=camera_module_cache_ram_10__0 A1=nx35824
+ B0=camera_module_cache_ram_26__0 B1=nx35864
Xcamera_module_cache_reg_ram_10__0 dffr $PINS Q=camera_module_cache_ram_10__0
+ QB=#dummy[958] D=nx2213 CLK=clk R=rst
Xix2214 mux21_ni $PINS Y=nx2213 A0=camera_module_cache_ram_10__0 A1=nx34208
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__0 dffr $PINS Q=camera_module_cache_ram_26__0
+ QB=#dummy[959] D=nx2203 CLK=clk R=rst
Xix2204 mux21_ni $PINS Y=nx2203 A0=camera_module_cache_ram_26__0 A1=nx34210
+ S0=nx34430
Xix28418 aoi22 $PINS Y=nx28417 A0=camera_module_cache_ram_42__0 A1=nx35904
+ B0=camera_module_cache_ram_58__0 B1=nx35944
Xcamera_module_cache_reg_ram_42__0 dffr $PINS Q=camera_module_cache_ram_42__0
+ QB=#dummy[960] D=nx2193 CLK=clk R=rst
Xix2194 mux21_ni $PINS Y=nx2193 A0=camera_module_cache_ram_42__0 A1=nx34210
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__0 dffr $PINS Q=camera_module_cache_ram_58__0
+ QB=#dummy[961] D=nx2183 CLK=clk R=rst
Xix2184 mux21_ni $PINS Y=nx2183 A0=camera_module_cache_ram_58__0 A1=nx34210
+ S0=nx34422
Xix28426 aoi22 $PINS Y=nx28425 A0=camera_module_cache_ram_74__0 A1=nx35984
+ B0=camera_module_cache_ram_90__0 B1=nx36024
Xcamera_module_cache_reg_ram_74__0 dffr $PINS Q=camera_module_cache_ram_74__0
+ QB=#dummy[962] D=nx2173 CLK=clk R=rst
Xix2174 mux21_ni $PINS Y=nx2173 A0=camera_module_cache_ram_74__0 A1=nx34210
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__0 dffr $PINS Q=camera_module_cache_ram_90__0
+ QB=#dummy[963] D=nx2163 CLK=clk R=rst
Xix2164 mux21_ni $PINS Y=nx2163 A0=camera_module_cache_ram_90__0 A1=nx34210
+ S0=nx34414
Xix28434 aoi22 $PINS Y=nx28433 A0=camera_module_cache_ram_122__0 A1=nx36064
+ B0=camera_module_cache_ram_106__0 B1=nx36104
Xcamera_module_cache_reg_ram_122__0 dffr $PINS Q=camera_module_cache_ram_122__0
+ QB=#dummy[964] D=nx2143 CLK=clk R=rst
Xix2144 mux21_ni $PINS Y=nx2143 A0=camera_module_cache_ram_122__0 A1=nx34210
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__0 dffr $PINS Q=camera_module_cache_ram_106__0
+ QB=#dummy[965] D=nx2153 CLK=clk R=rst
Xix2154 mux21_ni $PINS Y=nx2153 A0=camera_module_cache_ram_106__0 A1=nx34210
+ S0=nx34410
Xix2851 nand04 $PINS Y=nx2850 A0=nx28442 A1=nx28450 A2=nx28458 A3=nx28466
Xix28443 aoi22 $PINS Y=nx28442 A0=camera_module_cache_ram_138__0 A1=nx36144
+ B0=camera_module_cache_ram_154__0 B1=nx36184
Xcamera_module_cache_reg_ram_138__0 dffr $PINS Q=camera_module_cache_ram_138__0
+ QB=#dummy[966] D=nx2133 CLK=clk R=rst
Xix2134 mux21_ni $PINS Y=nx2133 A0=camera_module_cache_ram_138__0 A1=nx34212
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__0 dffr $PINS Q=camera_module_cache_ram_154__0
+ QB=#dummy[967] D=nx2123 CLK=clk R=rst
Xix2124 mux21_ni $PINS Y=nx2123 A0=camera_module_cache_ram_154__0 A1=nx34212
+ S0=nx34398
Xix28451 aoi22 $PINS Y=nx28450 A0=camera_module_cache_ram_186__0 A1=nx36224
+ B0=camera_module_cache_ram_170__0 B1=nx36264
Xcamera_module_cache_reg_ram_186__0 dffr $PINS Q=camera_module_cache_ram_186__0
+ QB=#dummy[968] D=nx2103 CLK=clk R=rst
Xix2104 mux21_ni $PINS Y=nx2103 A0=camera_module_cache_ram_186__0 A1=nx34212
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__0 dffr $PINS Q=camera_module_cache_ram_170__0
+ QB=#dummy[969] D=nx2113 CLK=clk R=rst
Xix2114 mux21_ni $PINS Y=nx2113 A0=camera_module_cache_ram_170__0 A1=nx34212
+ S0=nx34394
Xix28459 aoi22 $PINS Y=nx28458 A0=camera_module_cache_ram_202__0 A1=nx36304
+ B0=camera_module_cache_ram_218__0 B1=nx36344
Xcamera_module_cache_reg_ram_202__0 dffr $PINS Q=camera_module_cache_ram_202__0
+ QB=#dummy[970] D=nx2093 CLK=clk R=rst
Xix2094 mux21_ni $PINS Y=nx2093 A0=camera_module_cache_ram_202__0 A1=nx34212
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__0 dffr $PINS Q=camera_module_cache_ram_218__0
+ QB=#dummy[971] D=nx2083 CLK=clk R=rst
Xix2084 mux21_ni $PINS Y=nx2083 A0=camera_module_cache_ram_218__0 A1=nx34212
+ S0=nx34382
Xix28467 aoi22 $PINS Y=nx28466 A0=camera_module_cache_ram_234__0 A1=nx36384
+ B0=camera_module_cache_ram_250__0 B1=nx36424
Xcamera_module_cache_reg_ram_234__0 dffr $PINS Q=camera_module_cache_ram_234__0
+ QB=#dummy[972] D=nx2073 CLK=clk R=rst
Xix2074 mux21_ni $PINS Y=nx2073 A0=camera_module_cache_ram_234__0 A1=nx34212
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__0 dffr $PINS Q=camera_module_cache_ram_250__0
+ QB=#dummy[973] D=nx2063 CLK=clk R=rst
Xix2064 mux21_ni $PINS Y=nx2063 A0=camera_module_cache_ram_250__0 A1=nx34214
+ S0=nx34374
Xix28475 oai21 $PINS Y=nx28474 A0=nx2700 A1=nx2558 B0=nx36492
Xix2701 nand04 $PINS Y=nx2700 A0=nx28477 A1=nx28485 A2=nx28493 A3=nx28501
Xix28478 aoi22 $PINS Y=nx28477 A0=camera_module_cache_ram_11__0 A1=nx35826
+ B0=camera_module_cache_ram_27__0 B1=nx35866
Xcamera_module_cache_reg_ram_11__0 dffr $PINS Q=camera_module_cache_ram_11__0
+ QB=#dummy[974] D=nx2053 CLK=clk R=rst
Xix2054 mux21_ni $PINS Y=nx2053 A0=camera_module_cache_ram_11__0 A1=nx34214
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__0 dffr $PINS Q=camera_module_cache_ram_27__0
+ QB=#dummy[975] D=nx2043 CLK=clk R=rst
Xix2044 mux21_ni $PINS Y=nx2043 A0=camera_module_cache_ram_27__0 A1=nx34214
+ S0=nx34360
Xix28486 aoi22 $PINS Y=nx28485 A0=camera_module_cache_ram_43__0 A1=nx35906
+ B0=camera_module_cache_ram_59__0 B1=nx35946
Xcamera_module_cache_reg_ram_43__0 dffr $PINS Q=camera_module_cache_ram_43__0
+ QB=#dummy[976] D=nx2033 CLK=clk R=rst
Xix2034 mux21_ni $PINS Y=nx2033 A0=camera_module_cache_ram_43__0 A1=nx34214
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__0 dffr $PINS Q=camera_module_cache_ram_59__0
+ QB=#dummy[977] D=nx2023 CLK=clk R=rst
Xix2024 mux21_ni $PINS Y=nx2023 A0=camera_module_cache_ram_59__0 A1=nx34214
+ S0=nx34352
Xix28494 aoi22 $PINS Y=nx28493 A0=camera_module_cache_ram_75__0 A1=nx35986
+ B0=camera_module_cache_ram_91__0 B1=nx36026
Xcamera_module_cache_reg_ram_75__0 dffr $PINS Q=camera_module_cache_ram_75__0
+ QB=#dummy[978] D=nx2013 CLK=clk R=rst
Xix2014 mux21_ni $PINS Y=nx2013 A0=camera_module_cache_ram_75__0 A1=nx34214
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__0 dffr $PINS Q=camera_module_cache_ram_91__0
+ QB=#dummy[979] D=nx2003 CLK=clk R=rst
Xix2004 mux21_ni $PINS Y=nx2003 A0=camera_module_cache_ram_91__0 A1=nx34214
+ S0=nx34344
Xix28502 aoi22 $PINS Y=nx28501 A0=camera_module_cache_ram_123__0 A1=nx36066
+ B0=camera_module_cache_ram_107__0 B1=nx36106
Xcamera_module_cache_reg_ram_123__0 dffr $PINS Q=camera_module_cache_ram_123__0
+ QB=#dummy[980] D=nx1983 CLK=clk R=rst
Xix1984 mux21_ni $PINS Y=nx1983 A0=camera_module_cache_ram_123__0 A1=nx34216
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__0 dffr $PINS Q=camera_module_cache_ram_107__0
+ QB=#dummy[981] D=nx1993 CLK=clk R=rst
Xix1994 mux21_ni $PINS Y=nx1993 A0=camera_module_cache_ram_107__0 A1=nx34216
+ S0=nx34340
Xix2559 nand04 $PINS Y=nx2558 A0=nx28510 A1=nx28518 A2=nx28526 A3=nx28534
Xix28511 aoi22 $PINS Y=nx28510 A0=camera_module_cache_ram_139__0 A1=nx36146
+ B0=camera_module_cache_ram_155__0 B1=nx36186
Xcamera_module_cache_reg_ram_139__0 dffr $PINS Q=camera_module_cache_ram_139__0
+ QB=#dummy[982] D=nx1973 CLK=clk R=rst
Xix1974 mux21_ni $PINS Y=nx1973 A0=camera_module_cache_ram_139__0 A1=nx34216
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__0 dffr $PINS Q=camera_module_cache_ram_155__0
+ QB=#dummy[983] D=nx1963 CLK=clk R=rst
Xix1964 mux21_ni $PINS Y=nx1963 A0=camera_module_cache_ram_155__0 A1=nx34216
+ S0=nx34328
Xix28519 aoi22 $PINS Y=nx28518 A0=camera_module_cache_ram_187__0 A1=nx36226
+ B0=camera_module_cache_ram_171__0 B1=nx36266
Xcamera_module_cache_reg_ram_187__0 dffr $PINS Q=camera_module_cache_ram_187__0
+ QB=#dummy[984] D=nx1943 CLK=clk R=rst
Xix1944 mux21_ni $PINS Y=nx1943 A0=camera_module_cache_ram_187__0 A1=nx34216
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__0 dffr $PINS Q=camera_module_cache_ram_171__0
+ QB=#dummy[985] D=nx1953 CLK=clk R=rst
Xix1954 mux21_ni $PINS Y=nx1953 A0=camera_module_cache_ram_171__0 A1=nx34216
+ S0=nx34324
Xix28527 aoi22 $PINS Y=nx28526 A0=camera_module_cache_ram_203__0 A1=nx36306
+ B0=camera_module_cache_ram_219__0 B1=nx36346
Xcamera_module_cache_reg_ram_203__0 dffr $PINS Q=camera_module_cache_ram_203__0
+ QB=#dummy[986] D=nx1933 CLK=clk R=rst
Xix1934 mux21_ni $PINS Y=nx1933 A0=camera_module_cache_ram_203__0 A1=nx34216
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__0 dffr $PINS Q=camera_module_cache_ram_219__0
+ QB=#dummy[987] D=nx1923 CLK=clk R=rst
Xix1924 mux21_ni $PINS Y=nx1923 A0=camera_module_cache_ram_219__0 A1=nx34218
+ S0=nx34312
Xix28535 aoi22 $PINS Y=nx28534 A0=camera_module_cache_ram_235__0 A1=nx36386
+ B0=camera_module_cache_ram_251__0 B1=nx36426
Xcamera_module_cache_reg_ram_235__0 dffr $PINS Q=camera_module_cache_ram_235__0
+ QB=#dummy[988] D=nx1913 CLK=clk R=rst
Xix1914 mux21_ni $PINS Y=nx1913 A0=camera_module_cache_ram_235__0 A1=nx34218
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__0 dffr $PINS Q=camera_module_cache_ram_251__0
+ QB=#dummy[989] D=nx1903 CLK=clk R=rst
Xix1904 mux21_ni $PINS Y=nx1903 A0=camera_module_cache_ram_251__0 A1=nx34218
+ S0=nx34304
Xix2411 nand04 $PINS Y=nx2410 A0=nx28543 A1=nx28611 A2=nx28679 A3=nx28747
Xix28544 oai21 $PINS Y=nx28543 A0=nx2400 A1=nx2258 B0=nx36506
Xix2401 nand04 $PINS Y=nx2400 A0=nx28546 A1=nx28554 A2=nx28562 A3=nx28570
Xix28547 aoi22 $PINS Y=nx28546 A0=camera_module_cache_ram_12__0 A1=nx35826
+ B0=camera_module_cache_ram_28__0 B1=nx35866
Xcamera_module_cache_reg_ram_12__0 dffr $PINS Q=camera_module_cache_ram_12__0
+ QB=#dummy[990] D=nx1893 CLK=clk R=rst
Xix1894 mux21_ni $PINS Y=nx1893 A0=nx34218 A1=camera_module_cache_ram_12__0
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__0 dffr $PINS Q=camera_module_cache_ram_28__0
+ QB=#dummy[991] D=nx1883 CLK=clk R=rst
Xix1884 mux21_ni $PINS Y=nx1883 A0=nx34218 A1=camera_module_cache_ram_28__0
+ S0=nx36510
Xix28555 aoi22 $PINS Y=nx28554 A0=camera_module_cache_ram_44__0 A1=nx35906
+ B0=camera_module_cache_ram_60__0 B1=nx35946
Xcamera_module_cache_reg_ram_44__0 dffr $PINS Q=camera_module_cache_ram_44__0
+ QB=#dummy[992] D=nx1873 CLK=clk R=rst
Xix1874 mux21_ni $PINS Y=nx1873 A0=nx34218 A1=camera_module_cache_ram_44__0
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__0 dffr $PINS Q=camera_module_cache_ram_60__0
+ QB=#dummy[993] D=nx1863 CLK=clk R=rst
Xix1864 mux21_ni $PINS Y=nx1863 A0=nx34218 A1=camera_module_cache_ram_60__0
+ S0=nx36518
Xix28563 aoi22 $PINS Y=nx28562 A0=camera_module_cache_ram_76__0 A1=nx35986
+ B0=camera_module_cache_ram_92__0 B1=nx36026
Xcamera_module_cache_reg_ram_76__0 dffr $PINS Q=camera_module_cache_ram_76__0
+ QB=#dummy[994] D=nx1853 CLK=clk R=rst
Xix1854 mux21_ni $PINS Y=nx1853 A0=nx34220 A1=camera_module_cache_ram_76__0
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__0 dffr $PINS Q=camera_module_cache_ram_92__0
+ QB=#dummy[995] D=nx1843 CLK=clk R=rst
Xix1844 mux21_ni $PINS Y=nx1843 A0=nx34220 A1=camera_module_cache_ram_92__0
+ S0=nx36526
Xix28571 aoi22 $PINS Y=nx28570 A0=camera_module_cache_ram_124__0 A1=nx36066
+ B0=camera_module_cache_ram_108__0 B1=nx36106
Xcamera_module_cache_reg_ram_124__0 dffr $PINS Q=camera_module_cache_ram_124__0
+ QB=#dummy[996] D=nx1823 CLK=clk R=rst
Xix1824 mux21_ni $PINS Y=nx1823 A0=nx34220 A1=camera_module_cache_ram_124__0
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__0 dffr $PINS Q=camera_module_cache_ram_108__0
+ QB=#dummy[997] D=nx1833 CLK=clk R=rst
Xix1834 mux21_ni $PINS Y=nx1833 A0=nx34220 A1=camera_module_cache_ram_108__0
+ S0=nx36534
Xix2259 nand04 $PINS Y=nx2258 A0=nx28579 A1=nx28587 A2=nx28595 A3=nx28603
Xix28580 aoi22 $PINS Y=nx28579 A0=camera_module_cache_ram_140__0 A1=nx36146
+ B0=camera_module_cache_ram_156__0 B1=nx36186
Xcamera_module_cache_reg_ram_140__0 dffr $PINS Q=camera_module_cache_ram_140__0
+ QB=#dummy[998] D=nx1813 CLK=clk R=rst
Xix1814 mux21_ni $PINS Y=nx1813 A0=nx34220 A1=camera_module_cache_ram_140__0
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__0 dffr $PINS Q=camera_module_cache_ram_156__0
+ QB=#dummy[999] D=nx1803 CLK=clk R=rst
Xix1804 mux21_ni $PINS Y=nx1803 A0=nx34220 A1=camera_module_cache_ram_156__0
+ S0=nx36542
Xix28588 aoi22 $PINS Y=nx28587 A0=camera_module_cache_ram_188__0 A1=nx36226
+ B0=camera_module_cache_ram_172__0 B1=nx36266
Xcamera_module_cache_reg_ram_188__0 dffr $PINS Q=camera_module_cache_ram_188__0
+ QB=#dummy[1000] D=nx1783 CLK=clk R=rst
Xix1784 mux21_ni $PINS Y=nx1783 A0=nx34220 A1=camera_module_cache_ram_188__0
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__0 dffr $PINS Q=camera_module_cache_ram_172__0
+ QB=#dummy[1001] D=nx1793 CLK=clk R=rst
Xix1794 mux21_ni $PINS Y=nx1793 A0=nx34222 A1=camera_module_cache_ram_172__0
+ S0=nx36550
Xix28596 aoi22 $PINS Y=nx28595 A0=camera_module_cache_ram_204__0 A1=nx36306
+ B0=camera_module_cache_ram_220__0 B1=nx36346
Xcamera_module_cache_reg_ram_204__0 dffr $PINS Q=camera_module_cache_ram_204__0
+ QB=#dummy[1002] D=nx1773 CLK=clk R=rst
Xix1774 mux21_ni $PINS Y=nx1773 A0=nx34222 A1=camera_module_cache_ram_204__0
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__0 dffr $PINS Q=camera_module_cache_ram_220__0
+ QB=#dummy[1003] D=nx1763 CLK=clk R=rst
Xix1764 mux21_ni $PINS Y=nx1763 A0=nx34222 A1=camera_module_cache_ram_220__0
+ S0=nx36558
Xix28604 aoi22 $PINS Y=nx28603 A0=camera_module_cache_ram_236__0 A1=nx36386
+ B0=camera_module_cache_ram_252__0 B1=nx36426
Xcamera_module_cache_reg_ram_236__0 dffr $PINS Q=camera_module_cache_ram_236__0
+ QB=#dummy[1004] D=nx1753 CLK=clk R=rst
Xix1754 mux21_ni $PINS Y=nx1753 A0=nx34222 A1=camera_module_cache_ram_236__0
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__0 dffr $PINS Q=camera_module_cache_ram_252__0
+ QB=#dummy[1005] D=nx1743 CLK=clk R=rst
Xix1744 mux21_ni $PINS Y=nx1743 A0=nx34222 A1=camera_module_cache_ram_252__0
+ S0=nx36566
Xix28612 oai21 $PINS Y=nx28611 A0=nx2106 A1=nx1964 B0=nx36580
Xix2107 nand04 $PINS Y=nx2106 A0=nx28614 A1=nx28622 A2=nx28630 A3=nx28638
Xix28615 aoi22 $PINS Y=nx28614 A0=camera_module_cache_ram_13__0 A1=nx35826
+ B0=camera_module_cache_ram_29__0 B1=nx35866
Xcamera_module_cache_reg_ram_13__0 dffr $PINS Q=camera_module_cache_ram_13__0
+ QB=#dummy[1006] D=nx1733 CLK=clk R=rst
Xix1734 mux21_ni $PINS Y=nx1733 A0=nx34222 A1=camera_module_cache_ram_13__0
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__0 dffr $PINS Q=camera_module_cache_ram_29__0
+ QB=#dummy[1007] D=nx1723 CLK=clk R=rst
Xix1724 mux21_ni $PINS Y=nx1723 A0=nx34222 A1=camera_module_cache_ram_29__0
+ S0=nx36584
Xix28623 aoi22 $PINS Y=nx28622 A0=camera_module_cache_ram_45__0 A1=nx35906
+ B0=camera_module_cache_ram_61__0 B1=nx35946
Xcamera_module_cache_reg_ram_45__0 dffr $PINS Q=camera_module_cache_ram_45__0
+ QB=#dummy[1008] D=nx1713 CLK=clk R=rst
Xix1714 mux21_ni $PINS Y=nx1713 A0=nx34224 A1=camera_module_cache_ram_45__0
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__0 dffr $PINS Q=camera_module_cache_ram_61__0
+ QB=#dummy[1009] D=nx1703 CLK=clk R=rst
Xix1704 mux21_ni $PINS Y=nx1703 A0=nx34224 A1=camera_module_cache_ram_61__0
+ S0=nx36592
Xix28631 aoi22 $PINS Y=nx28630 A0=camera_module_cache_ram_77__0 A1=nx35986
+ B0=camera_module_cache_ram_93__0 B1=nx36026
Xcamera_module_cache_reg_ram_77__0 dffr $PINS Q=camera_module_cache_ram_77__0
+ QB=#dummy[1010] D=nx1693 CLK=clk R=rst
Xix1694 mux21_ni $PINS Y=nx1693 A0=nx34224 A1=camera_module_cache_ram_77__0
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__0 dffr $PINS Q=camera_module_cache_ram_93__0
+ QB=#dummy[1011] D=nx1683 CLK=clk R=rst
Xix1684 mux21_ni $PINS Y=nx1683 A0=nx34224 A1=camera_module_cache_ram_93__0
+ S0=nx36600
Xix28639 aoi22 $PINS Y=nx28638 A0=camera_module_cache_ram_125__0 A1=nx36066
+ B0=camera_module_cache_ram_109__0 B1=nx36106
Xcamera_module_cache_reg_ram_125__0 dffr $PINS Q=camera_module_cache_ram_125__0
+ QB=#dummy[1012] D=nx1663 CLK=clk R=rst
Xix1664 mux21_ni $PINS Y=nx1663 A0=nx34224 A1=camera_module_cache_ram_125__0
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__0 dffr $PINS Q=camera_module_cache_ram_109__0
+ QB=#dummy[1013] D=nx1673 CLK=clk R=rst
Xix1674 mux21_ni $PINS Y=nx1673 A0=nx34224 A1=camera_module_cache_ram_109__0
+ S0=nx36608
Xix1965 nand04 $PINS Y=nx1964 A0=nx28647 A1=nx28655 A2=nx28663 A3=nx28671
Xix28648 aoi22 $PINS Y=nx28647 A0=camera_module_cache_ram_141__0 A1=nx36146
+ B0=camera_module_cache_ram_157__0 B1=nx36186
Xcamera_module_cache_reg_ram_141__0 dffr $PINS Q=camera_module_cache_ram_141__0
+ QB=#dummy[1014] D=nx1653 CLK=clk R=rst
Xix1654 mux21_ni $PINS Y=nx1653 A0=nx34224 A1=camera_module_cache_ram_141__0
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__0 dffr $PINS Q=camera_module_cache_ram_157__0
+ QB=#dummy[1015] D=nx1643 CLK=clk R=rst
Xix1644 mux21_ni $PINS Y=nx1643 A0=nx34226 A1=camera_module_cache_ram_157__0
+ S0=nx36616
Xix28656 aoi22 $PINS Y=nx28655 A0=camera_module_cache_ram_189__0 A1=nx36226
+ B0=camera_module_cache_ram_173__0 B1=nx36266
Xcamera_module_cache_reg_ram_189__0 dffr $PINS Q=camera_module_cache_ram_189__0
+ QB=#dummy[1016] D=nx1623 CLK=clk R=rst
Xix1624 mux21_ni $PINS Y=nx1623 A0=nx34226 A1=camera_module_cache_ram_189__0
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__0 dffr $PINS Q=camera_module_cache_ram_173__0
+ QB=#dummy[1017] D=nx1633 CLK=clk R=rst
Xix1634 mux21_ni $PINS Y=nx1633 A0=nx34226 A1=camera_module_cache_ram_173__0
+ S0=nx36624
Xix28664 aoi22 $PINS Y=nx28663 A0=camera_module_cache_ram_205__0 A1=nx36306
+ B0=camera_module_cache_ram_221__0 B1=nx36346
Xcamera_module_cache_reg_ram_205__0 dffr $PINS Q=camera_module_cache_ram_205__0
+ QB=#dummy[1018] D=nx1613 CLK=clk R=rst
Xix1614 mux21_ni $PINS Y=nx1613 A0=nx34226 A1=camera_module_cache_ram_205__0
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__0 dffr $PINS Q=camera_module_cache_ram_221__0
+ QB=#dummy[1019] D=nx1603 CLK=clk R=rst
Xix1604 mux21_ni $PINS Y=nx1603 A0=nx34226 A1=camera_module_cache_ram_221__0
+ S0=nx36632
Xix28672 aoi22 $PINS Y=nx28671 A0=camera_module_cache_ram_237__0 A1=nx36386
+ B0=camera_module_cache_ram_253__0 B1=nx36426
Xcamera_module_cache_reg_ram_237__0 dffr $PINS Q=camera_module_cache_ram_237__0
+ QB=#dummy[1020] D=nx1593 CLK=clk R=rst
Xix1594 mux21_ni $PINS Y=nx1593 A0=nx34226 A1=camera_module_cache_ram_237__0
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__0 dffr $PINS Q=camera_module_cache_ram_253__0
+ QB=#dummy[1021] D=nx1583 CLK=clk R=rst
Xix1584 mux21_ni $PINS Y=nx1583 A0=nx34226 A1=camera_module_cache_ram_253__0
+ S0=nx36640
Xix28680 oai21 $PINS Y=nx28679 A0=nx1808 A1=nx1666 B0=nx36654
Xix1809 nand04 $PINS Y=nx1808 A0=nx28682 A1=nx28690 A2=nx28698 A3=nx28706
Xix28683 aoi22 $PINS Y=nx28682 A0=camera_module_cache_ram_14__0 A1=nx35826
+ B0=camera_module_cache_ram_30__0 B1=nx35866
Xcamera_module_cache_reg_ram_14__0 dffr $PINS Q=camera_module_cache_ram_14__0
+ QB=#dummy[1022] D=nx1573 CLK=clk R=rst
Xix1574 mux21_ni $PINS Y=nx1573 A0=nx34228 A1=camera_module_cache_ram_14__0
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__0 dffr $PINS Q=camera_module_cache_ram_30__0
+ QB=#dummy[1023] D=nx1563 CLK=clk R=rst
Xix1564 mux21_ni $PINS Y=nx1563 A0=nx34228 A1=camera_module_cache_ram_30__0
+ S0=nx36658
Xix28691 aoi22 $PINS Y=nx28690 A0=camera_module_cache_ram_46__0 A1=nx35906
+ B0=camera_module_cache_ram_62__0 B1=nx35946
Xcamera_module_cache_reg_ram_46__0 dffr $PINS Q=camera_module_cache_ram_46__0
+ QB=#dummy[1024] D=nx1553 CLK=clk R=rst
Xix1554 mux21_ni $PINS Y=nx1553 A0=nx34228 A1=camera_module_cache_ram_46__0
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__0 dffr $PINS Q=camera_module_cache_ram_62__0
+ QB=#dummy[1025] D=nx1543 CLK=clk R=rst
Xix1544 mux21_ni $PINS Y=nx1543 A0=nx34228 A1=camera_module_cache_ram_62__0
+ S0=nx36666
Xix28699 aoi22 $PINS Y=nx28698 A0=camera_module_cache_ram_78__0 A1=nx35986
+ B0=camera_module_cache_ram_94__0 B1=nx36026
Xcamera_module_cache_reg_ram_78__0 dffr $PINS Q=camera_module_cache_ram_78__0
+ QB=#dummy[1026] D=nx1533 CLK=clk R=rst
Xix1534 mux21_ni $PINS Y=nx1533 A0=nx34228 A1=camera_module_cache_ram_78__0
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__0 dffr $PINS Q=camera_module_cache_ram_94__0
+ QB=#dummy[1027] D=nx1523 CLK=clk R=rst
Xix1524 mux21_ni $PINS Y=nx1523 A0=nx34228 A1=camera_module_cache_ram_94__0
+ S0=nx36674
Xix28707 aoi22 $PINS Y=nx28706 A0=camera_module_cache_ram_126__0 A1=nx36066
+ B0=camera_module_cache_ram_110__0 B1=nx36106
Xcamera_module_cache_reg_ram_126__0 dffr $PINS Q=camera_module_cache_ram_126__0
+ QB=#dummy[1028] D=nx1503 CLK=clk R=rst
Xix1504 mux21_ni $PINS Y=nx1503 A0=nx34228 A1=camera_module_cache_ram_126__0
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__0 dffr $PINS Q=camera_module_cache_ram_110__0
+ QB=#dummy[1029] D=nx1513 CLK=clk R=rst
Xix1514 mux21_ni $PINS Y=nx1513 A0=nx34230 A1=camera_module_cache_ram_110__0
+ S0=nx36682
Xix1667 nand04 $PINS Y=nx1666 A0=nx28715 A1=nx28723 A2=nx28731 A3=nx28739
Xix28716 aoi22 $PINS Y=nx28715 A0=camera_module_cache_ram_142__0 A1=nx36146
+ B0=camera_module_cache_ram_158__0 B1=nx36186
Xcamera_module_cache_reg_ram_142__0 dffr $PINS Q=camera_module_cache_ram_142__0
+ QB=#dummy[1030] D=nx1493 CLK=clk R=rst
Xix1494 mux21_ni $PINS Y=nx1493 A0=nx34230 A1=camera_module_cache_ram_142__0
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__0 dffr $PINS Q=camera_module_cache_ram_158__0
+ QB=#dummy[1031] D=nx1483 CLK=clk R=rst
Xix1484 mux21_ni $PINS Y=nx1483 A0=nx34230 A1=camera_module_cache_ram_158__0
+ S0=nx36690
Xix28724 aoi22 $PINS Y=nx28723 A0=camera_module_cache_ram_190__0 A1=nx36226
+ B0=camera_module_cache_ram_174__0 B1=nx36266
Xcamera_module_cache_reg_ram_190__0 dffr $PINS Q=camera_module_cache_ram_190__0
+ QB=#dummy[1032] D=nx1463 CLK=clk R=rst
Xix1464 mux21_ni $PINS Y=nx1463 A0=nx34230 A1=camera_module_cache_ram_190__0
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__0 dffr $PINS Q=camera_module_cache_ram_174__0
+ QB=#dummy[1033] D=nx1473 CLK=clk R=rst
Xix1474 mux21_ni $PINS Y=nx1473 A0=nx34230 A1=camera_module_cache_ram_174__0
+ S0=nx36698
Xix28732 aoi22 $PINS Y=nx28731 A0=camera_module_cache_ram_206__0 A1=nx36306
+ B0=camera_module_cache_ram_222__0 B1=nx36346
Xcamera_module_cache_reg_ram_206__0 dffr $PINS Q=camera_module_cache_ram_206__0
+ QB=#dummy[1034] D=nx1453 CLK=clk R=rst
Xix1454 mux21_ni $PINS Y=nx1453 A0=nx34230 A1=camera_module_cache_ram_206__0
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__0 dffr $PINS Q=camera_module_cache_ram_222__0
+ QB=#dummy[1035] D=nx1443 CLK=clk R=rst
Xix1444 mux21_ni $PINS Y=nx1443 A0=nx34230 A1=camera_module_cache_ram_222__0
+ S0=nx36706
Xix28740 aoi22 $PINS Y=nx28739 A0=camera_module_cache_ram_238__0 A1=nx36386
+ B0=camera_module_cache_ram_254__0 B1=nx36426
Xcamera_module_cache_reg_ram_238__0 dffr $PINS Q=camera_module_cache_ram_238__0
+ QB=#dummy[1036] D=nx1433 CLK=clk R=rst
Xix1434 mux21_ni $PINS Y=nx1433 A0=nx34232 A1=camera_module_cache_ram_238__0
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__0 dffr $PINS Q=camera_module_cache_ram_254__0
+ QB=#dummy[1037] D=nx1423 CLK=clk R=rst
Xix1424 mux21_ni $PINS Y=nx1423 A0=nx34232 A1=camera_module_cache_ram_254__0
+ S0=nx36714
Xix28748 oai21 $PINS Y=nx28747 A0=nx1512 A1=nx1348 B0=nx36728
Xix1513 nand04 $PINS Y=nx1512 A0=nx28750 A1=nx28758 A2=nx28766 A3=nx28774
Xix28751 aoi22 $PINS Y=nx28750 A0=camera_module_cache_ram_15__0 A1=nx35826
+ B0=camera_module_cache_ram_31__0 B1=nx35866
Xcamera_module_cache_reg_ram_15__0 dffr $PINS Q=camera_module_cache_ram_15__0
+ QB=#dummy[1038] D=nx1413 CLK=clk R=rst
Xix1414 mux21_ni $PINS Y=nx1413 A0=nx34232 A1=camera_module_cache_ram_15__0
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__0 dffr $PINS Q=camera_module_cache_ram_31__0
+ QB=#dummy[1039] D=nx1403 CLK=clk R=rst
Xix1404 mux21_ni $PINS Y=nx1403 A0=nx34232 A1=camera_module_cache_ram_31__0
+ S0=nx36732
Xix28759 aoi22 $PINS Y=nx28758 A0=camera_module_cache_ram_47__0 A1=nx35906
+ B0=camera_module_cache_ram_63__0 B1=nx35946
Xcamera_module_cache_reg_ram_47__0 dffr $PINS Q=camera_module_cache_ram_47__0
+ QB=#dummy[1040] D=nx1393 CLK=clk R=rst
Xix1394 mux21_ni $PINS Y=nx1393 A0=nx34232 A1=camera_module_cache_ram_47__0
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__0 dffr $PINS Q=camera_module_cache_ram_63__0
+ QB=#dummy[1041] D=nx1383 CLK=clk R=rst
Xix1384 mux21_ni $PINS Y=nx1383 A0=nx34232 A1=camera_module_cache_ram_63__0
+ S0=nx36740
Xix28767 aoi22 $PINS Y=nx28766 A0=camera_module_cache_ram_79__0 A1=nx35986
+ B0=camera_module_cache_ram_95__0 B1=nx36026
Xcamera_module_cache_reg_ram_79__0 dffr $PINS Q=camera_module_cache_ram_79__0
+ QB=#dummy[1042] D=nx1373 CLK=clk R=rst
Xix1374 mux21_ni $PINS Y=nx1373 A0=nx34232 A1=camera_module_cache_ram_79__0
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__0 dffr $PINS Q=camera_module_cache_ram_95__0
+ QB=#dummy[1043] D=nx1363 CLK=clk R=rst
Xix1364 mux21_ni $PINS Y=nx1363 A0=nx34234 A1=camera_module_cache_ram_95__0
+ S0=nx36748
Xix28775 aoi22 $PINS Y=nx28774 A0=camera_module_cache_ram_127__0 A1=nx36066
+ B0=camera_module_cache_ram_111__0 B1=nx36106
Xcamera_module_cache_reg_ram_127__0 dffr $PINS Q=camera_module_cache_ram_127__0
+ QB=#dummy[1044] D=nx1343 CLK=clk R=rst
Xix1344 mux21_ni $PINS Y=nx1343 A0=nx34234 A1=camera_module_cache_ram_127__0
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__0 dffr $PINS Q=camera_module_cache_ram_111__0
+ QB=#dummy[1045] D=nx1353 CLK=clk R=rst
Xix1354 mux21_ni $PINS Y=nx1353 A0=nx34234 A1=camera_module_cache_ram_111__0
+ S0=nx36756
Xix1349 nand04 $PINS Y=nx1348 A0=nx28783 A1=nx28791 A2=nx28799 A3=nx28807
Xix28784 aoi22 $PINS Y=nx28783 A0=camera_module_cache_ram_143__0 A1=nx36146
+ B0=camera_module_cache_ram_159__0 B1=nx36186
Xcamera_module_cache_reg_ram_143__0 dffr $PINS Q=camera_module_cache_ram_143__0
+ QB=#dummy[1046] D=nx1333 CLK=clk R=rst
Xix1334 mux21_ni $PINS Y=nx1333 A0=nx34234 A1=camera_module_cache_ram_143__0
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__0 dffr $PINS Q=camera_module_cache_ram_159__0
+ QB=#dummy[1047] D=nx1323 CLK=clk R=rst
Xix1324 mux21_ni $PINS Y=nx1323 A0=nx34234 A1=camera_module_cache_ram_159__0
+ S0=nx36764
Xix28792 aoi22 $PINS Y=nx28791 A0=camera_module_cache_ram_191__0 A1=nx36226
+ B0=camera_module_cache_ram_175__0 B1=nx36266
Xcamera_module_cache_reg_ram_191__0 dffr $PINS Q=camera_module_cache_ram_191__0
+ QB=#dummy[1048] D=nx1303 CLK=clk R=rst
Xix1304 mux21_ni $PINS Y=nx1303 A0=nx34234 A1=camera_module_cache_ram_191__0
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__0 dffr $PINS Q=camera_module_cache_ram_175__0
+ QB=#dummy[1049] D=nx1313 CLK=clk R=rst
Xix1314 mux21_ni $PINS Y=nx1313 A0=nx34234 A1=camera_module_cache_ram_175__0
+ S0=nx36772
Xix28800 aoi22 $PINS Y=nx28799 A0=camera_module_cache_ram_207__0 A1=nx36306
+ B0=camera_module_cache_ram_223__0 B1=nx36346
Xcamera_module_cache_reg_ram_207__0 dffr $PINS Q=camera_module_cache_ram_207__0
+ QB=#dummy[1050] D=nx1293 CLK=clk R=rst
Xix1294 mux21_ni $PINS Y=nx1293 A0=nx34236 A1=camera_module_cache_ram_207__0
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__0 dffr $PINS Q=camera_module_cache_ram_223__0
+ QB=#dummy[1051] D=nx1283 CLK=clk R=rst
Xix1284 mux21_ni $PINS Y=nx1283 A0=nx34236 A1=camera_module_cache_ram_223__0
+ S0=nx36780
Xix28808 aoi22 $PINS Y=nx28807 A0=camera_module_cache_ram_239__0 A1=nx36386
+ B0=camera_module_cache_ram_255__0 B1=nx36426
Xcamera_module_cache_reg_ram_239__0 dffr $PINS Q=camera_module_cache_ram_239__0
+ QB=#dummy[1052] D=nx1273 CLK=clk R=rst
Xix1274 mux21_ni $PINS Y=nx1273 A0=nx34236 A1=camera_module_cache_ram_239__0
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__0 dffr $PINS Q=camera_module_cache_ram_255__0
+ QB=#dummy[1053] D=nx1263 CLK=clk R=rst
Xix1264 mux21_ni $PINS Y=nx1263 A0=nx34236 A1=camera_module_cache_ram_255__0
+ S0=nx36788
Xcamera_module_algo_module_pixel_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_pixel_value_1 QB=nx29956 D=nx6393 CLK=clk
Xix6394 mux21_ni $PINS Y=nx6393 A0=nx8738
+ A1=camera_module_algo_module_pixel_value_1 S0=nx37152
Xix28823 mux21_ni $PINS Y=nx28822 A0=nx28824 A1=nx35676 S0=nx36792
Xix28825 nor04 $PINS Y=nx28824 A0=nx8718 A1=nx8064 A2=nx7408 A3=nx6754
Xix8719 nand04 $PINS Y=nx8718 A0=nx28827 A1=nx28933 A2=nx29001 A3=nx29069
Xix28828 oai21 $PINS Y=nx28827 A0=nx8708 A1=nx8630 B0=nx36448
Xix8709 nand04 $PINS Y=nx8708 A0=nx28830 A1=nx28876 A2=nx28884 A3=nx28892
Xix28831 aoi22 $PINS Y=nx28830 A0=camera_module_cache_ram_0__1 A1=nx35826
+ B0=camera_module_cache_ram_16__1 B1=nx35866
Xcamera_module_cache_reg_ram_0__1 dffr $PINS Q=camera_module_cache_ram_0__1
+ QB=#dummy[1054] D=nx6383 CLK=clk R=rst
Xix6384 mux21_ni $PINS Y=nx6383 A0=camera_module_cache_ram_0__1 A1=nx35140
+ S0=nx35134
Xix6101 oai221 $PINS Y=nx6100 A0=nx34074 A1=nx28835 B0=nx28851 B1=nx35712
+ C0=nx28854
Xnvm_module_tri_dataout_121 tri01 $PINS Y=nvm_data_121 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_113 tri01 $PINS Y=nvm_data_113 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_105 tri01 $PINS Y=nvm_data_105 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_97 tri01 $PINS Y=nvm_data_97 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_89 tri01 $PINS Y=nvm_data_89 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_81 tri01 $PINS Y=nvm_data_81 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_73 tri01 $PINS Y=nvm_data_73 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_65 tri01 $PINS Y=nvm_data_65 A=nx22549
+ E=nvm_module_GND0
Xix28852 inv01 $PINS Y=nx28851 A=nvm_data_1
Xnvm_module_tri_dataout_1 tri01 $PINS Y=nvm_data_1 A=nx22549 E=nvm_module_GND0
Xix28855 nand02 $PINS Y=nx28854 A0=nx34074 A1=nx6034
Xnvm_module_tri_dataout_57 tri01 $PINS Y=nvm_data_57 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_49 tri01 $PINS Y=nvm_data_49 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_41 tri01 $PINS Y=nvm_data_41 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_33 tri01 $PINS Y=nvm_data_33 A=nx22549
+ E=nvm_module_GND0
Xix6003 oai22 $PINS Y=nx6002 A0=nx34104 A1=nx28865 B0=nx34090 B1=nx28869
Xnvm_module_tri_dataout_25 tri01 $PINS Y=nvm_data_25 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_17 tri01 $PINS Y=nvm_data_17 A=nx22549
+ E=nvm_module_GND0
Xix28870 nand02 $PINS Y=nx28869 A0=nvm_data_9 A1=nx34106
Xnvm_module_tri_dataout_9 tri01 $PINS Y=nvm_data_9 A=nx22549 E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__1 dffr $PINS Q=camera_module_cache_ram_16__1
+ QB=#dummy[1055] D=nx6373 CLK=clk R=rst
Xix6374 mux21_ni $PINS Y=nx6373 A0=camera_module_cache_ram_16__1 A1=nx35140
+ S0=nx35130
Xix28877 aoi22 $PINS Y=nx28876 A0=camera_module_cache_ram_32__1 A1=nx35906
+ B0=camera_module_cache_ram_48__1 B1=nx35946
Xcamera_module_cache_reg_ram_32__1 dffr $PINS Q=camera_module_cache_ram_32__1
+ QB=#dummy[1056] D=nx6363 CLK=clk R=rst
Xix6364 mux21_ni $PINS Y=nx6363 A0=camera_module_cache_ram_32__1 A1=nx35140
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__1 dffr $PINS Q=camera_module_cache_ram_48__1
+ QB=#dummy[1057] D=nx6353 CLK=clk R=rst
Xix6354 mux21_ni $PINS Y=nx6353 A0=camera_module_cache_ram_48__1 A1=nx35140
+ S0=nx35122
Xix28885 aoi22 $PINS Y=nx28884 A0=camera_module_cache_ram_64__1 A1=nx35986
+ B0=camera_module_cache_ram_80__1 B1=nx36026
Xcamera_module_cache_reg_ram_64__1 dffr $PINS Q=camera_module_cache_ram_64__1
+ QB=#dummy[1058] D=nx6343 CLK=clk R=rst
Xix6344 mux21_ni $PINS Y=nx6343 A0=camera_module_cache_ram_64__1 A1=nx35140
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__1 dffr $PINS Q=camera_module_cache_ram_80__1
+ QB=#dummy[1059] D=nx6333 CLK=clk R=rst
Xix6334 mux21_ni $PINS Y=nx6333 A0=camera_module_cache_ram_80__1 A1=nx35140
+ S0=nx35114
Xix28893 aoi22 $PINS Y=nx28892 A0=camera_module_cache_ram_112__1 A1=nx36066
+ B0=camera_module_cache_ram_96__1 B1=nx36106
Xcamera_module_cache_reg_ram_112__1 dffr $PINS Q=camera_module_cache_ram_112__1
+ QB=#dummy[1060] D=nx6313 CLK=clk R=rst
Xix6314 mux21_ni $PINS Y=nx6313 A0=camera_module_cache_ram_112__1 A1=nx35140
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__1 dffr $PINS Q=camera_module_cache_ram_96__1
+ QB=#dummy[1061] D=nx6323 CLK=clk R=rst
Xix6324 mux21_ni $PINS Y=nx6323 A0=camera_module_cache_ram_96__1 A1=nx35142
+ S0=nx35110
Xix8631 nand04 $PINS Y=nx8630 A0=nx28901 A1=nx28909 A2=nx28917 A3=nx28925
Xix28902 aoi22 $PINS Y=nx28901 A0=camera_module_cache_ram_128__1 A1=nx36146
+ B0=camera_module_cache_ram_144__1 B1=nx36186
Xcamera_module_cache_reg_ram_128__1 dffr $PINS Q=camera_module_cache_ram_128__1
+ QB=#dummy[1062] D=nx6303 CLK=clk R=rst
Xix6304 mux21_ni $PINS Y=nx6303 A0=camera_module_cache_ram_128__1 A1=nx35142
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__1 dffr $PINS Q=camera_module_cache_ram_144__1
+ QB=#dummy[1063] D=nx6293 CLK=clk R=rst
Xix6294 mux21_ni $PINS Y=nx6293 A0=camera_module_cache_ram_144__1 A1=nx35142
+ S0=nx35098
Xix28910 aoi22 $PINS Y=nx28909 A0=camera_module_cache_ram_176__1 A1=nx36226
+ B0=camera_module_cache_ram_160__1 B1=nx36266
Xcamera_module_cache_reg_ram_176__1 dffr $PINS Q=camera_module_cache_ram_176__1
+ QB=#dummy[1064] D=nx6273 CLK=clk R=rst
Xix6274 mux21_ni $PINS Y=nx6273 A0=camera_module_cache_ram_176__1 A1=nx35142
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__1 dffr $PINS Q=camera_module_cache_ram_160__1
+ QB=#dummy[1065] D=nx6283 CLK=clk R=rst
Xix6284 mux21_ni $PINS Y=nx6283 A0=camera_module_cache_ram_160__1 A1=nx35142
+ S0=nx35094
Xix28918 aoi22 $PINS Y=nx28917 A0=camera_module_cache_ram_192__1 A1=nx36306
+ B0=camera_module_cache_ram_208__1 B1=nx36346
Xcamera_module_cache_reg_ram_192__1 dffr $PINS Q=camera_module_cache_ram_192__1
+ QB=#dummy[1066] D=nx6263 CLK=clk R=rst
Xix6264 mux21_ni $PINS Y=nx6263 A0=camera_module_cache_ram_192__1 A1=nx35142
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__1 dffr $PINS Q=camera_module_cache_ram_208__1
+ QB=#dummy[1067] D=nx6253 CLK=clk R=rst
Xix6254 mux21_ni $PINS Y=nx6253 A0=camera_module_cache_ram_208__1 A1=nx35142
+ S0=nx35082
Xix28926 aoi22 $PINS Y=nx28925 A0=camera_module_cache_ram_224__1 A1=nx36386
+ B0=camera_module_cache_ram_240__1 B1=nx36426
Xcamera_module_cache_reg_ram_224__1 dffr $PINS Q=camera_module_cache_ram_224__1
+ QB=#dummy[1068] D=nx6243 CLK=clk R=rst
Xix6244 mux21_ni $PINS Y=nx6243 A0=camera_module_cache_ram_224__1 A1=nx35144
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__1 dffr $PINS Q=camera_module_cache_ram_240__1
+ QB=#dummy[1069] D=nx6233 CLK=clk R=rst
Xix6234 mux21_ni $PINS Y=nx6233 A0=camera_module_cache_ram_240__1 A1=nx35144
+ S0=nx35074
Xix28934 oai21 $PINS Y=nx28933 A0=nx8546 A1=nx8468 B0=nx36452
Xix8547 nand04 $PINS Y=nx8546 A0=nx28936 A1=nx28944 A2=nx28952 A3=nx28960
Xix28937 aoi22 $PINS Y=nx28936 A0=camera_module_cache_ram_1__1 A1=nx35826
+ B0=camera_module_cache_ram_17__1 B1=nx35866
Xcamera_module_cache_reg_ram_1__1 dffr $PINS Q=camera_module_cache_ram_1__1
+ QB=#dummy[1070] D=nx6223 CLK=clk R=rst
Xix6224 mux21_ni $PINS Y=nx6223 A0=camera_module_cache_ram_1__1 A1=nx35144
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__1 dffr $PINS Q=camera_module_cache_ram_17__1
+ QB=#dummy[1071] D=nx6213 CLK=clk R=rst
Xix6214 mux21_ni $PINS Y=nx6213 A0=camera_module_cache_ram_17__1 A1=nx35144
+ S0=nx35060
Xix28945 aoi22 $PINS Y=nx28944 A0=camera_module_cache_ram_33__1 A1=nx35906
+ B0=camera_module_cache_ram_49__1 B1=nx35946
Xcamera_module_cache_reg_ram_33__1 dffr $PINS Q=camera_module_cache_ram_33__1
+ QB=#dummy[1072] D=nx6203 CLK=clk R=rst
Xix6204 mux21_ni $PINS Y=nx6203 A0=camera_module_cache_ram_33__1 A1=nx35144
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__1 dffr $PINS Q=camera_module_cache_ram_49__1
+ QB=#dummy[1073] D=nx6193 CLK=clk R=rst
Xix6194 mux21_ni $PINS Y=nx6193 A0=camera_module_cache_ram_49__1 A1=nx35144
+ S0=nx35052
Xix28953 aoi22 $PINS Y=nx28952 A0=camera_module_cache_ram_65__1 A1=nx35986
+ B0=camera_module_cache_ram_81__1 B1=nx36026
Xcamera_module_cache_reg_ram_65__1 dffr $PINS Q=camera_module_cache_ram_65__1
+ QB=#dummy[1074] D=nx6183 CLK=clk R=rst
Xix6184 mux21_ni $PINS Y=nx6183 A0=camera_module_cache_ram_65__1 A1=nx35144
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__1 dffr $PINS Q=camera_module_cache_ram_81__1
+ QB=#dummy[1075] D=nx6173 CLK=clk R=rst
Xix6174 mux21_ni $PINS Y=nx6173 A0=camera_module_cache_ram_81__1 A1=nx35146
+ S0=nx35044
Xix28961 aoi22 $PINS Y=nx28960 A0=camera_module_cache_ram_113__1 A1=nx36066
+ B0=camera_module_cache_ram_97__1 B1=nx36106
Xcamera_module_cache_reg_ram_113__1 dffr $PINS Q=camera_module_cache_ram_113__1
+ QB=#dummy[1076] D=nx6153 CLK=clk R=rst
Xix6154 mux21_ni $PINS Y=nx6153 A0=camera_module_cache_ram_113__1 A1=nx35146
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__1 dffr $PINS Q=camera_module_cache_ram_97__1
+ QB=#dummy[1077] D=nx6163 CLK=clk R=rst
Xix6164 mux21_ni $PINS Y=nx6163 A0=camera_module_cache_ram_97__1 A1=nx35146
+ S0=nx35040
Xix8469 nand04 $PINS Y=nx8468 A0=nx28969 A1=nx28977 A2=nx28985 A3=nx28993
Xix28970 aoi22 $PINS Y=nx28969 A0=camera_module_cache_ram_129__1 A1=nx36146
+ B0=camera_module_cache_ram_145__1 B1=nx36186
Xcamera_module_cache_reg_ram_129__1 dffr $PINS Q=camera_module_cache_ram_129__1
+ QB=#dummy[1078] D=nx6143 CLK=clk R=rst
Xix6144 mux21_ni $PINS Y=nx6143 A0=camera_module_cache_ram_129__1 A1=nx35146
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__1 dffr $PINS Q=camera_module_cache_ram_145__1
+ QB=#dummy[1079] D=nx6133 CLK=clk R=rst
Xix6134 mux21_ni $PINS Y=nx6133 A0=camera_module_cache_ram_145__1 A1=nx35146
+ S0=nx35028
Xix28978 aoi22 $PINS Y=nx28977 A0=camera_module_cache_ram_177__1 A1=nx36226
+ B0=camera_module_cache_ram_161__1 B1=nx36266
Xcamera_module_cache_reg_ram_177__1 dffr $PINS Q=camera_module_cache_ram_177__1
+ QB=#dummy[1080] D=nx6113 CLK=clk R=rst
Xix6114 mux21_ni $PINS Y=nx6113 A0=camera_module_cache_ram_177__1 A1=nx35146
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__1 dffr $PINS Q=camera_module_cache_ram_161__1
+ QB=#dummy[1081] D=nx6123 CLK=clk R=rst
Xix6124 mux21_ni $PINS Y=nx6123 A0=camera_module_cache_ram_161__1 A1=nx35146
+ S0=nx35024
Xix28986 aoi22 $PINS Y=nx28985 A0=camera_module_cache_ram_193__1 A1=nx36306
+ B0=camera_module_cache_ram_209__1 B1=nx36346
Xcamera_module_cache_reg_ram_193__1 dffr $PINS Q=camera_module_cache_ram_193__1
+ QB=#dummy[1082] D=nx6103 CLK=clk R=rst
Xix6104 mux21_ni $PINS Y=nx6103 A0=camera_module_cache_ram_193__1 A1=nx35148
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__1 dffr $PINS Q=camera_module_cache_ram_209__1
+ QB=#dummy[1083] D=nx6093 CLK=clk R=rst
Xix6094 mux21_ni $PINS Y=nx6093 A0=camera_module_cache_ram_209__1 A1=nx35148
+ S0=nx35012
Xix28994 aoi22 $PINS Y=nx28993 A0=camera_module_cache_ram_225__1 A1=nx36386
+ B0=camera_module_cache_ram_241__1 B1=nx36426
Xcamera_module_cache_reg_ram_225__1 dffr $PINS Q=camera_module_cache_ram_225__1
+ QB=#dummy[1084] D=nx6083 CLK=clk R=rst
Xix6084 mux21_ni $PINS Y=nx6083 A0=camera_module_cache_ram_225__1 A1=nx35148
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__1 dffr $PINS Q=camera_module_cache_ram_241__1
+ QB=#dummy[1085] D=nx6073 CLK=clk R=rst
Xix6074 mux21_ni $PINS Y=nx6073 A0=camera_module_cache_ram_241__1 A1=nx35148
+ S0=nx35004
Xix29002 oai21 $PINS Y=nx29001 A0=nx8382 A1=nx8304 B0=nx36456
Xix8383 nand04 $PINS Y=nx8382 A0=nx29004 A1=nx29012 A2=nx29020 A3=nx29028
Xix29005 aoi22 $PINS Y=nx29004 A0=camera_module_cache_ram_2__1 A1=nx35828
+ B0=camera_module_cache_ram_18__1 B1=nx35868
Xcamera_module_cache_reg_ram_2__1 dffr $PINS Q=camera_module_cache_ram_2__1
+ QB=#dummy[1086] D=nx6063 CLK=clk R=rst
Xix6064 mux21_ni $PINS Y=nx6063 A0=camera_module_cache_ram_2__1 A1=nx35148
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__1 dffr $PINS Q=camera_module_cache_ram_18__1
+ QB=#dummy[1087] D=nx6053 CLK=clk R=rst
Xix6054 mux21_ni $PINS Y=nx6053 A0=camera_module_cache_ram_18__1 A1=nx35148
+ S0=nx34990
Xix29013 aoi22 $PINS Y=nx29012 A0=camera_module_cache_ram_34__1 A1=nx35908
+ B0=camera_module_cache_ram_50__1 B1=nx35948
Xcamera_module_cache_reg_ram_34__1 dffr $PINS Q=camera_module_cache_ram_34__1
+ QB=#dummy[1088] D=nx6043 CLK=clk R=rst
Xix6044 mux21_ni $PINS Y=nx6043 A0=camera_module_cache_ram_34__1 A1=nx35148
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__1 dffr $PINS Q=camera_module_cache_ram_50__1
+ QB=#dummy[1089] D=nx6033 CLK=clk R=rst
Xix6034 mux21_ni $PINS Y=nx6033 A0=camera_module_cache_ram_50__1 A1=nx35150
+ S0=nx34982
Xix29021 aoi22 $PINS Y=nx29020 A0=camera_module_cache_ram_66__1 A1=nx35988
+ B0=camera_module_cache_ram_82__1 B1=nx36028
Xcamera_module_cache_reg_ram_66__1 dffr $PINS Q=camera_module_cache_ram_66__1
+ QB=#dummy[1090] D=nx6023 CLK=clk R=rst
Xix6024 mux21_ni $PINS Y=nx6023 A0=camera_module_cache_ram_66__1 A1=nx35150
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__1 dffr $PINS Q=camera_module_cache_ram_82__1
+ QB=#dummy[1091] D=nx6013 CLK=clk R=rst
Xix6014 mux21_ni $PINS Y=nx6013 A0=camera_module_cache_ram_82__1 A1=nx35150
+ S0=nx34974
Xix29029 aoi22 $PINS Y=nx29028 A0=camera_module_cache_ram_114__1 A1=nx36068
+ B0=camera_module_cache_ram_98__1 B1=nx36108
Xcamera_module_cache_reg_ram_114__1 dffr $PINS Q=camera_module_cache_ram_114__1
+ QB=#dummy[1092] D=nx5993 CLK=clk R=rst
Xix5994 mux21_ni $PINS Y=nx5993 A0=camera_module_cache_ram_114__1 A1=nx35150
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__1 dffr $PINS Q=camera_module_cache_ram_98__1
+ QB=#dummy[1093] D=nx6003 CLK=clk R=rst
Xix6004 mux21_ni $PINS Y=nx6003 A0=camera_module_cache_ram_98__1 A1=nx35150
+ S0=nx34970
Xix8305 nand04 $PINS Y=nx8304 A0=nx29037 A1=nx29045 A2=nx29053 A3=nx29061
Xix29038 aoi22 $PINS Y=nx29037 A0=camera_module_cache_ram_130__1 A1=nx36148
+ B0=camera_module_cache_ram_146__1 B1=nx36188
Xcamera_module_cache_reg_ram_130__1 dffr $PINS Q=camera_module_cache_ram_130__1
+ QB=#dummy[1094] D=nx5983 CLK=clk R=rst
Xix5984 mux21_ni $PINS Y=nx5983 A0=camera_module_cache_ram_130__1 A1=nx35150
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__1 dffr $PINS Q=camera_module_cache_ram_146__1
+ QB=#dummy[1095] D=nx5973 CLK=clk R=rst
Xix5974 mux21_ni $PINS Y=nx5973 A0=camera_module_cache_ram_146__1 A1=nx35150
+ S0=nx34958
Xix29046 aoi22 $PINS Y=nx29045 A0=camera_module_cache_ram_178__1 A1=nx36228
+ B0=camera_module_cache_ram_162__1 B1=nx36268
Xcamera_module_cache_reg_ram_178__1 dffr $PINS Q=camera_module_cache_ram_178__1
+ QB=#dummy[1096] D=nx5953 CLK=clk R=rst
Xix5954 mux21_ni $PINS Y=nx5953 A0=camera_module_cache_ram_178__1 A1=nx35152
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__1 dffr $PINS Q=camera_module_cache_ram_162__1
+ QB=#dummy[1097] D=nx5963 CLK=clk R=rst
Xix5964 mux21_ni $PINS Y=nx5963 A0=camera_module_cache_ram_162__1 A1=nx35152
+ S0=nx34954
Xix29054 aoi22 $PINS Y=nx29053 A0=camera_module_cache_ram_194__1 A1=nx36308
+ B0=camera_module_cache_ram_210__1 B1=nx36348
Xcamera_module_cache_reg_ram_194__1 dffr $PINS Q=camera_module_cache_ram_194__1
+ QB=#dummy[1098] D=nx5943 CLK=clk R=rst
Xix5944 mux21_ni $PINS Y=nx5943 A0=camera_module_cache_ram_194__1 A1=nx35152
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__1 dffr $PINS Q=camera_module_cache_ram_210__1
+ QB=#dummy[1099] D=nx5933 CLK=clk R=rst
Xix5934 mux21_ni $PINS Y=nx5933 A0=camera_module_cache_ram_210__1 A1=nx35152
+ S0=nx34942
Xix29062 aoi22 $PINS Y=nx29061 A0=camera_module_cache_ram_226__1 A1=nx36388
+ B0=camera_module_cache_ram_242__1 B1=nx36428
Xcamera_module_cache_reg_ram_226__1 dffr $PINS Q=camera_module_cache_ram_226__1
+ QB=#dummy[1100] D=nx5923 CLK=clk R=rst
Xix5924 mux21_ni $PINS Y=nx5923 A0=camera_module_cache_ram_226__1 A1=nx35152
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__1 dffr $PINS Q=camera_module_cache_ram_242__1
+ QB=#dummy[1101] D=nx5913 CLK=clk R=rst
Xix5914 mux21_ni $PINS Y=nx5913 A0=camera_module_cache_ram_242__1 A1=nx35152
+ S0=nx34934
Xix29070 oai21 $PINS Y=nx29069 A0=nx8220 A1=nx8142 B0=nx36460
Xix8221 nand04 $PINS Y=nx8220 A0=nx29072 A1=nx29080 A2=nx29088 A3=nx29096
Xix29073 aoi22 $PINS Y=nx29072 A0=camera_module_cache_ram_3__1 A1=nx35828
+ B0=camera_module_cache_ram_19__1 B1=nx35868
Xcamera_module_cache_reg_ram_3__1 dffr $PINS Q=camera_module_cache_ram_3__1
+ QB=#dummy[1102] D=nx5903 CLK=clk R=rst
Xix5904 mux21_ni $PINS Y=nx5903 A0=camera_module_cache_ram_3__1 A1=nx35152
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__1 dffr $PINS Q=camera_module_cache_ram_19__1
+ QB=#dummy[1103] D=nx5893 CLK=clk R=rst
Xix5894 mux21_ni $PINS Y=nx5893 A0=camera_module_cache_ram_19__1 A1=nx35154
+ S0=nx34920
Xix29081 aoi22 $PINS Y=nx29080 A0=camera_module_cache_ram_35__1 A1=nx35908
+ B0=camera_module_cache_ram_51__1 B1=nx35948
Xcamera_module_cache_reg_ram_35__1 dffr $PINS Q=camera_module_cache_ram_35__1
+ QB=#dummy[1104] D=nx5883 CLK=clk R=rst
Xix5884 mux21_ni $PINS Y=nx5883 A0=camera_module_cache_ram_35__1 A1=nx35154
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__1 dffr $PINS Q=camera_module_cache_ram_51__1
+ QB=#dummy[1105] D=nx5873 CLK=clk R=rst
Xix5874 mux21_ni $PINS Y=nx5873 A0=camera_module_cache_ram_51__1 A1=nx35154
+ S0=nx34912
Xix29089 aoi22 $PINS Y=nx29088 A0=camera_module_cache_ram_67__1 A1=nx35988
+ B0=camera_module_cache_ram_83__1 B1=nx36028
Xcamera_module_cache_reg_ram_67__1 dffr $PINS Q=camera_module_cache_ram_67__1
+ QB=#dummy[1106] D=nx5863 CLK=clk R=rst
Xix5864 mux21_ni $PINS Y=nx5863 A0=camera_module_cache_ram_67__1 A1=nx35154
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__1 dffr $PINS Q=camera_module_cache_ram_83__1
+ QB=#dummy[1107] D=nx5853 CLK=clk R=rst
Xix5854 mux21_ni $PINS Y=nx5853 A0=camera_module_cache_ram_83__1 A1=nx35154
+ S0=nx34904
Xix29097 aoi22 $PINS Y=nx29096 A0=camera_module_cache_ram_115__1 A1=nx36068
+ B0=camera_module_cache_ram_99__1 B1=nx36108
Xcamera_module_cache_reg_ram_115__1 dffr $PINS Q=camera_module_cache_ram_115__1
+ QB=#dummy[1108] D=nx5833 CLK=clk R=rst
Xix5834 mux21_ni $PINS Y=nx5833 A0=camera_module_cache_ram_115__1 A1=nx35154
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__1 dffr $PINS Q=camera_module_cache_ram_99__1
+ QB=#dummy[1109] D=nx5843 CLK=clk R=rst
Xix5844 mux21_ni $PINS Y=nx5843 A0=camera_module_cache_ram_99__1 A1=nx35154
+ S0=nx34900
Xix8143 nand04 $PINS Y=nx8142 A0=nx29105 A1=nx29113 A2=nx29121 A3=nx29129
Xix29106 aoi22 $PINS Y=nx29105 A0=camera_module_cache_ram_131__1 A1=nx36148
+ B0=camera_module_cache_ram_147__1 B1=nx36188
Xcamera_module_cache_reg_ram_131__1 dffr $PINS Q=camera_module_cache_ram_131__1
+ QB=#dummy[1110] D=nx5823 CLK=clk R=rst
Xix5824 mux21_ni $PINS Y=nx5823 A0=camera_module_cache_ram_131__1 A1=nx35156
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__1 dffr $PINS Q=camera_module_cache_ram_147__1
+ QB=#dummy[1111] D=nx5813 CLK=clk R=rst
Xix5814 mux21_ni $PINS Y=nx5813 A0=camera_module_cache_ram_147__1 A1=nx35156
+ S0=nx34888
Xix29114 aoi22 $PINS Y=nx29113 A0=camera_module_cache_ram_179__1 A1=nx36228
+ B0=camera_module_cache_ram_163__1 B1=nx36268
Xcamera_module_cache_reg_ram_179__1 dffr $PINS Q=camera_module_cache_ram_179__1
+ QB=#dummy[1112] D=nx5793 CLK=clk R=rst
Xix5794 mux21_ni $PINS Y=nx5793 A0=camera_module_cache_ram_179__1 A1=nx35156
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__1 dffr $PINS Q=camera_module_cache_ram_163__1
+ QB=#dummy[1113] D=nx5803 CLK=clk R=rst
Xix5804 mux21_ni $PINS Y=nx5803 A0=camera_module_cache_ram_163__1 A1=nx35156
+ S0=nx34884
Xix29122 aoi22 $PINS Y=nx29121 A0=camera_module_cache_ram_195__1 A1=nx36308
+ B0=camera_module_cache_ram_211__1 B1=nx36348
Xcamera_module_cache_reg_ram_195__1 dffr $PINS Q=camera_module_cache_ram_195__1
+ QB=#dummy[1114] D=nx5783 CLK=clk R=rst
Xix5784 mux21_ni $PINS Y=nx5783 A0=camera_module_cache_ram_195__1 A1=nx35156
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__1 dffr $PINS Q=camera_module_cache_ram_211__1
+ QB=#dummy[1115] D=nx5773 CLK=clk R=rst
Xix5774 mux21_ni $PINS Y=nx5773 A0=camera_module_cache_ram_211__1 A1=nx35156
+ S0=nx34872
Xix29130 aoi22 $PINS Y=nx29129 A0=camera_module_cache_ram_227__1 A1=nx36388
+ B0=camera_module_cache_ram_243__1 B1=nx36428
Xcamera_module_cache_reg_ram_227__1 dffr $PINS Q=camera_module_cache_ram_227__1
+ QB=#dummy[1116] D=nx5763 CLK=clk R=rst
Xix5764 mux21_ni $PINS Y=nx5763 A0=camera_module_cache_ram_227__1 A1=nx35156
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__1 dffr $PINS Q=camera_module_cache_ram_243__1
+ QB=#dummy[1117] D=nx5753 CLK=clk R=rst
Xix5754 mux21_ni $PINS Y=nx5753 A0=camera_module_cache_ram_243__1 A1=nx35158
+ S0=nx34864
Xix8065 nand04 $PINS Y=nx8064 A0=nx29138 A1=nx29206 A2=nx29274 A3=nx29342
Xix29139 oai21 $PINS Y=nx29138 A0=nx8054 A1=nx7976 B0=nx36464
Xix8055 nand04 $PINS Y=nx8054 A0=nx29141 A1=nx29149 A2=nx29157 A3=nx29165
Xix29142 aoi22 $PINS Y=nx29141 A0=camera_module_cache_ram_4__1 A1=nx35828
+ B0=camera_module_cache_ram_20__1 B1=nx35868
Xcamera_module_cache_reg_ram_4__1 dffr $PINS Q=camera_module_cache_ram_4__1
+ QB=#dummy[1118] D=nx5743 CLK=clk R=rst
Xix5744 mux21_ni $PINS Y=nx5743 A0=camera_module_cache_ram_4__1 A1=nx35158
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__1 dffr $PINS Q=camera_module_cache_ram_20__1
+ QB=#dummy[1119] D=nx5733 CLK=clk R=rst
Xix5734 mux21_ni $PINS Y=nx5733 A0=camera_module_cache_ram_20__1 A1=nx35158
+ S0=nx34850
Xix29150 aoi22 $PINS Y=nx29149 A0=camera_module_cache_ram_36__1 A1=nx35908
+ B0=camera_module_cache_ram_52__1 B1=nx35948
Xcamera_module_cache_reg_ram_36__1 dffr $PINS Q=camera_module_cache_ram_36__1
+ QB=#dummy[1120] D=nx5723 CLK=clk R=rst
Xix5724 mux21_ni $PINS Y=nx5723 A0=camera_module_cache_ram_36__1 A1=nx35158
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__1 dffr $PINS Q=camera_module_cache_ram_52__1
+ QB=#dummy[1121] D=nx5713 CLK=clk R=rst
Xix5714 mux21_ni $PINS Y=nx5713 A0=camera_module_cache_ram_52__1 A1=nx35158
+ S0=nx34842
Xix29158 aoi22 $PINS Y=nx29157 A0=camera_module_cache_ram_68__1 A1=nx35988
+ B0=camera_module_cache_ram_84__1 B1=nx36028
Xcamera_module_cache_reg_ram_68__1 dffr $PINS Q=camera_module_cache_ram_68__1
+ QB=#dummy[1122] D=nx5703 CLK=clk R=rst
Xix5704 mux21_ni $PINS Y=nx5703 A0=camera_module_cache_ram_68__1 A1=nx35158
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__1 dffr $PINS Q=camera_module_cache_ram_84__1
+ QB=#dummy[1123] D=nx5693 CLK=clk R=rst
Xix5694 mux21_ni $PINS Y=nx5693 A0=camera_module_cache_ram_84__1 A1=nx35158
+ S0=nx34834
Xix29166 aoi22 $PINS Y=nx29165 A0=camera_module_cache_ram_116__1 A1=nx36068
+ B0=camera_module_cache_ram_100__1 B1=nx36108
Xcamera_module_cache_reg_ram_116__1 dffr $PINS Q=camera_module_cache_ram_116__1
+ QB=#dummy[1124] D=nx5673 CLK=clk R=rst
Xix5674 mux21_ni $PINS Y=nx5673 A0=camera_module_cache_ram_116__1 A1=nx35160
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__1 dffr $PINS Q=camera_module_cache_ram_100__1
+ QB=#dummy[1125] D=nx5683 CLK=clk R=rst
Xix5684 mux21_ni $PINS Y=nx5683 A0=camera_module_cache_ram_100__1 A1=nx35160
+ S0=nx34830
Xix7977 nand04 $PINS Y=nx7976 A0=nx29174 A1=nx29182 A2=nx29190 A3=nx29198
Xix29175 aoi22 $PINS Y=nx29174 A0=camera_module_cache_ram_132__1 A1=nx36148
+ B0=camera_module_cache_ram_148__1 B1=nx36188
Xcamera_module_cache_reg_ram_132__1 dffr $PINS Q=camera_module_cache_ram_132__1
+ QB=#dummy[1126] D=nx5663 CLK=clk R=rst
Xix5664 mux21_ni $PINS Y=nx5663 A0=camera_module_cache_ram_132__1 A1=nx35160
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__1 dffr $PINS Q=camera_module_cache_ram_148__1
+ QB=#dummy[1127] D=nx5653 CLK=clk R=rst
Xix5654 mux21_ni $PINS Y=nx5653 A0=camera_module_cache_ram_148__1 A1=nx35160
+ S0=nx34818
Xix29183 aoi22 $PINS Y=nx29182 A0=camera_module_cache_ram_180__1 A1=nx36228
+ B0=camera_module_cache_ram_164__1 B1=nx36268
Xcamera_module_cache_reg_ram_180__1 dffr $PINS Q=camera_module_cache_ram_180__1
+ QB=#dummy[1128] D=nx5633 CLK=clk R=rst
Xix5634 mux21_ni $PINS Y=nx5633 A0=camera_module_cache_ram_180__1 A1=nx35160
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__1 dffr $PINS Q=camera_module_cache_ram_164__1
+ QB=#dummy[1129] D=nx5643 CLK=clk R=rst
Xix5644 mux21_ni $PINS Y=nx5643 A0=camera_module_cache_ram_164__1 A1=nx35160
+ S0=nx34814
Xix29191 aoi22 $PINS Y=nx29190 A0=camera_module_cache_ram_196__1 A1=nx36308
+ B0=camera_module_cache_ram_212__1 B1=nx36348
Xcamera_module_cache_reg_ram_196__1 dffr $PINS Q=camera_module_cache_ram_196__1
+ QB=#dummy[1130] D=nx5623 CLK=clk R=rst
Xix5624 mux21_ni $PINS Y=nx5623 A0=camera_module_cache_ram_196__1 A1=nx35160
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__1 dffr $PINS Q=camera_module_cache_ram_212__1
+ QB=#dummy[1131] D=nx5613 CLK=clk R=rst
Xix5614 mux21_ni $PINS Y=nx5613 A0=camera_module_cache_ram_212__1 A1=nx35162
+ S0=nx34802
Xix29199 aoi22 $PINS Y=nx29198 A0=camera_module_cache_ram_228__1 A1=nx36388
+ B0=camera_module_cache_ram_244__1 B1=nx36428
Xcamera_module_cache_reg_ram_228__1 dffr $PINS Q=camera_module_cache_ram_228__1
+ QB=#dummy[1132] D=nx5603 CLK=clk R=rst
Xix5604 mux21_ni $PINS Y=nx5603 A0=camera_module_cache_ram_228__1 A1=nx35162
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__1 dffr $PINS Q=camera_module_cache_ram_244__1
+ QB=#dummy[1133] D=nx5593 CLK=clk R=rst
Xix5594 mux21_ni $PINS Y=nx5593 A0=camera_module_cache_ram_244__1 A1=nx35162
+ S0=nx34794
Xix29207 oai21 $PINS Y=nx29206 A0=nx7892 A1=nx7814 B0=nx36468
Xix7893 nand04 $PINS Y=nx7892 A0=nx29209 A1=nx29217 A2=nx29225 A3=nx29233
Xix29210 aoi22 $PINS Y=nx29209 A0=camera_module_cache_ram_5__1 A1=nx35828
+ B0=camera_module_cache_ram_21__1 B1=nx35868
Xcamera_module_cache_reg_ram_5__1 dffr $PINS Q=camera_module_cache_ram_5__1
+ QB=#dummy[1134] D=nx5583 CLK=clk R=rst
Xix5584 mux21_ni $PINS Y=nx5583 A0=camera_module_cache_ram_5__1 A1=nx35162
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__1 dffr $PINS Q=camera_module_cache_ram_21__1
+ QB=#dummy[1135] D=nx5573 CLK=clk R=rst
Xix5574 mux21_ni $PINS Y=nx5573 A0=camera_module_cache_ram_21__1 A1=nx35162
+ S0=nx34780
Xix29218 aoi22 $PINS Y=nx29217 A0=camera_module_cache_ram_37__1 A1=nx35908
+ B0=camera_module_cache_ram_53__1 B1=nx35948
Xcamera_module_cache_reg_ram_37__1 dffr $PINS Q=camera_module_cache_ram_37__1
+ QB=#dummy[1136] D=nx5563 CLK=clk R=rst
Xix5564 mux21_ni $PINS Y=nx5563 A0=camera_module_cache_ram_37__1 A1=nx35162
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__1 dffr $PINS Q=camera_module_cache_ram_53__1
+ QB=#dummy[1137] D=nx5553 CLK=clk R=rst
Xix5554 mux21_ni $PINS Y=nx5553 A0=camera_module_cache_ram_53__1 A1=nx35162
+ S0=nx34772
Xix29226 aoi22 $PINS Y=nx29225 A0=camera_module_cache_ram_69__1 A1=nx35988
+ B0=camera_module_cache_ram_85__1 B1=nx36028
Xcamera_module_cache_reg_ram_69__1 dffr $PINS Q=camera_module_cache_ram_69__1
+ QB=#dummy[1138] D=nx5543 CLK=clk R=rst
Xix5544 mux21_ni $PINS Y=nx5543 A0=camera_module_cache_ram_69__1 A1=nx35164
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__1 dffr $PINS Q=camera_module_cache_ram_85__1
+ QB=#dummy[1139] D=nx5533 CLK=clk R=rst
Xix5534 mux21_ni $PINS Y=nx5533 A0=camera_module_cache_ram_85__1 A1=nx35164
+ S0=nx34764
Xix29234 aoi22 $PINS Y=nx29233 A0=camera_module_cache_ram_117__1 A1=nx36068
+ B0=camera_module_cache_ram_101__1 B1=nx36108
Xcamera_module_cache_reg_ram_117__1 dffr $PINS Q=camera_module_cache_ram_117__1
+ QB=#dummy[1140] D=nx5513 CLK=clk R=rst
Xix5514 mux21_ni $PINS Y=nx5513 A0=camera_module_cache_ram_117__1 A1=nx35164
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__1 dffr $PINS Q=camera_module_cache_ram_101__1
+ QB=#dummy[1141] D=nx5523 CLK=clk R=rst
Xix5524 mux21_ni $PINS Y=nx5523 A0=camera_module_cache_ram_101__1 A1=nx35164
+ S0=nx34760
Xix7815 nand04 $PINS Y=nx7814 A0=nx29242 A1=nx29250 A2=nx29258 A3=nx29266
Xix29243 aoi22 $PINS Y=nx29242 A0=camera_module_cache_ram_133__1 A1=nx36148
+ B0=camera_module_cache_ram_149__1 B1=nx36188
Xcamera_module_cache_reg_ram_133__1 dffr $PINS Q=camera_module_cache_ram_133__1
+ QB=#dummy[1142] D=nx5503 CLK=clk R=rst
Xix5504 mux21_ni $PINS Y=nx5503 A0=camera_module_cache_ram_133__1 A1=nx35164
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__1 dffr $PINS Q=camera_module_cache_ram_149__1
+ QB=#dummy[1143] D=nx5493 CLK=clk R=rst
Xix5494 mux21_ni $PINS Y=nx5493 A0=camera_module_cache_ram_149__1 A1=nx35164
+ S0=nx34748
Xix29251 aoi22 $PINS Y=nx29250 A0=camera_module_cache_ram_181__1 A1=nx36228
+ B0=camera_module_cache_ram_165__1 B1=nx36268
Xcamera_module_cache_reg_ram_181__1 dffr $PINS Q=camera_module_cache_ram_181__1
+ QB=#dummy[1144] D=nx5473 CLK=clk R=rst
Xix5474 mux21_ni $PINS Y=nx5473 A0=camera_module_cache_ram_181__1 A1=nx35164
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__1 dffr $PINS Q=camera_module_cache_ram_165__1
+ QB=#dummy[1145] D=nx5483 CLK=clk R=rst
Xix5484 mux21_ni $PINS Y=nx5483 A0=camera_module_cache_ram_165__1 A1=nx35166
+ S0=nx34744
Xix29259 aoi22 $PINS Y=nx29258 A0=camera_module_cache_ram_197__1 A1=nx36308
+ B0=camera_module_cache_ram_213__1 B1=nx36348
Xcamera_module_cache_reg_ram_197__1 dffr $PINS Q=camera_module_cache_ram_197__1
+ QB=#dummy[1146] D=nx5463 CLK=clk R=rst
Xix5464 mux21_ni $PINS Y=nx5463 A0=camera_module_cache_ram_197__1 A1=nx35166
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__1 dffr $PINS Q=camera_module_cache_ram_213__1
+ QB=#dummy[1147] D=nx5453 CLK=clk R=rst
Xix5454 mux21_ni $PINS Y=nx5453 A0=camera_module_cache_ram_213__1 A1=nx35166
+ S0=nx34732
Xix29267 aoi22 $PINS Y=nx29266 A0=camera_module_cache_ram_229__1 A1=nx36388
+ B0=camera_module_cache_ram_245__1 B1=nx36428
Xcamera_module_cache_reg_ram_229__1 dffr $PINS Q=camera_module_cache_ram_229__1
+ QB=#dummy[1148] D=nx5443 CLK=clk R=rst
Xix5444 mux21_ni $PINS Y=nx5443 A0=camera_module_cache_ram_229__1 A1=nx35166
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__1 dffr $PINS Q=camera_module_cache_ram_245__1
+ QB=#dummy[1149] D=nx5433 CLK=clk R=rst
Xix5434 mux21_ni $PINS Y=nx5433 A0=camera_module_cache_ram_245__1 A1=nx35166
+ S0=nx34724
Xix29275 oai21 $PINS Y=nx29274 A0=nx7728 A1=nx7650 B0=nx36472
Xix7729 nand04 $PINS Y=nx7728 A0=nx29277 A1=nx29285 A2=nx29293 A3=nx29301
Xix29278 aoi22 $PINS Y=nx29277 A0=camera_module_cache_ram_6__1 A1=nx35828
+ B0=camera_module_cache_ram_22__1 B1=nx35868
Xcamera_module_cache_reg_ram_6__1 dffr $PINS Q=camera_module_cache_ram_6__1
+ QB=#dummy[1150] D=nx5423 CLK=clk R=rst
Xix5424 mux21_ni $PINS Y=nx5423 A0=camera_module_cache_ram_6__1 A1=nx35166
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__1 dffr $PINS Q=camera_module_cache_ram_22__1
+ QB=#dummy[1151] D=nx5413 CLK=clk R=rst
Xix5414 mux21_ni $PINS Y=nx5413 A0=camera_module_cache_ram_22__1 A1=nx35166
+ S0=nx34710
Xix29286 aoi22 $PINS Y=nx29285 A0=camera_module_cache_ram_38__1 A1=nx35908
+ B0=camera_module_cache_ram_54__1 B1=nx35948
Xcamera_module_cache_reg_ram_38__1 dffr $PINS Q=camera_module_cache_ram_38__1
+ QB=#dummy[1152] D=nx5403 CLK=clk R=rst
Xix5404 mux21_ni $PINS Y=nx5403 A0=camera_module_cache_ram_38__1 A1=nx35168
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__1 dffr $PINS Q=camera_module_cache_ram_54__1
+ QB=#dummy[1153] D=nx5393 CLK=clk R=rst
Xix5394 mux21_ni $PINS Y=nx5393 A0=camera_module_cache_ram_54__1 A1=nx35168
+ S0=nx34702
Xix29294 aoi22 $PINS Y=nx29293 A0=camera_module_cache_ram_70__1 A1=nx35988
+ B0=camera_module_cache_ram_86__1 B1=nx36028
Xcamera_module_cache_reg_ram_70__1 dffr $PINS Q=camera_module_cache_ram_70__1
+ QB=#dummy[1154] D=nx5383 CLK=clk R=rst
Xix5384 mux21_ni $PINS Y=nx5383 A0=camera_module_cache_ram_70__1 A1=nx35168
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__1 dffr $PINS Q=camera_module_cache_ram_86__1
+ QB=#dummy[1155] D=nx5373 CLK=clk R=rst
Xix5374 mux21_ni $PINS Y=nx5373 A0=camera_module_cache_ram_86__1 A1=nx35168
+ S0=nx34694
Xix29302 aoi22 $PINS Y=nx29301 A0=camera_module_cache_ram_118__1 A1=nx36068
+ B0=camera_module_cache_ram_102__1 B1=nx36108
Xcamera_module_cache_reg_ram_118__1 dffr $PINS Q=camera_module_cache_ram_118__1
+ QB=#dummy[1156] D=nx5353 CLK=clk R=rst
Xix5354 mux21_ni $PINS Y=nx5353 A0=camera_module_cache_ram_118__1 A1=nx35168
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__1 dffr $PINS Q=camera_module_cache_ram_102__1
+ QB=#dummy[1157] D=nx5363 CLK=clk R=rst
Xix5364 mux21_ni $PINS Y=nx5363 A0=camera_module_cache_ram_102__1 A1=nx35168
+ S0=nx34690
Xix7651 nand04 $PINS Y=nx7650 A0=nx29310 A1=nx29318 A2=nx29326 A3=nx29334
Xix29311 aoi22 $PINS Y=nx29310 A0=camera_module_cache_ram_134__1 A1=nx36148
+ B0=camera_module_cache_ram_150__1 B1=nx36188
Xcamera_module_cache_reg_ram_134__1 dffr $PINS Q=camera_module_cache_ram_134__1
+ QB=#dummy[1158] D=nx5343 CLK=clk R=rst
Xix5344 mux21_ni $PINS Y=nx5343 A0=camera_module_cache_ram_134__1 A1=nx35168
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__1 dffr $PINS Q=camera_module_cache_ram_150__1
+ QB=#dummy[1159] D=nx5333 CLK=clk R=rst
Xix5334 mux21_ni $PINS Y=nx5333 A0=camera_module_cache_ram_150__1 A1=nx35170
+ S0=nx34678
Xix29319 aoi22 $PINS Y=nx29318 A0=camera_module_cache_ram_182__1 A1=nx36228
+ B0=camera_module_cache_ram_166__1 B1=nx36268
Xcamera_module_cache_reg_ram_182__1 dffr $PINS Q=camera_module_cache_ram_182__1
+ QB=#dummy[1160] D=nx5313 CLK=clk R=rst
Xix5314 mux21_ni $PINS Y=nx5313 A0=camera_module_cache_ram_182__1 A1=nx35170
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__1 dffr $PINS Q=camera_module_cache_ram_166__1
+ QB=#dummy[1161] D=nx5323 CLK=clk R=rst
Xix5324 mux21_ni $PINS Y=nx5323 A0=camera_module_cache_ram_166__1 A1=nx35170
+ S0=nx34674
Xix29327 aoi22 $PINS Y=nx29326 A0=camera_module_cache_ram_198__1 A1=nx36308
+ B0=camera_module_cache_ram_214__1 B1=nx36348
Xcamera_module_cache_reg_ram_198__1 dffr $PINS Q=camera_module_cache_ram_198__1
+ QB=#dummy[1162] D=nx5303 CLK=clk R=rst
Xix5304 mux21_ni $PINS Y=nx5303 A0=camera_module_cache_ram_198__1 A1=nx35170
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__1 dffr $PINS Q=camera_module_cache_ram_214__1
+ QB=#dummy[1163] D=nx5293 CLK=clk R=rst
Xix5294 mux21_ni $PINS Y=nx5293 A0=camera_module_cache_ram_214__1 A1=nx35170
+ S0=nx34662
Xix29335 aoi22 $PINS Y=nx29334 A0=camera_module_cache_ram_230__1 A1=nx36388
+ B0=camera_module_cache_ram_246__1 B1=nx36428
Xcamera_module_cache_reg_ram_230__1 dffr $PINS Q=camera_module_cache_ram_230__1
+ QB=#dummy[1164] D=nx5283 CLK=clk R=rst
Xix5284 mux21_ni $PINS Y=nx5283 A0=camera_module_cache_ram_230__1 A1=nx35170
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__1 dffr $PINS Q=camera_module_cache_ram_246__1
+ QB=#dummy[1165] D=nx5273 CLK=clk R=rst
Xix5274 mux21_ni $PINS Y=nx5273 A0=camera_module_cache_ram_246__1 A1=nx35170
+ S0=nx34654
Xix29343 oai21 $PINS Y=nx29342 A0=nx7566 A1=nx7488 B0=nx36476
Xix7567 nand04 $PINS Y=nx7566 A0=nx29345 A1=nx29353 A2=nx29361 A3=nx29369
Xix29346 aoi22 $PINS Y=nx29345 A0=camera_module_cache_ram_7__1 A1=nx35828
+ B0=camera_module_cache_ram_23__1 B1=nx35868
Xcamera_module_cache_reg_ram_7__1 dffr $PINS Q=camera_module_cache_ram_7__1
+ QB=#dummy[1166] D=nx5263 CLK=clk R=rst
Xix5264 mux21_ni $PINS Y=nx5263 A0=camera_module_cache_ram_7__1 A1=nx35172
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__1 dffr $PINS Q=camera_module_cache_ram_23__1
+ QB=#dummy[1167] D=nx5253 CLK=clk R=rst
Xix5254 mux21_ni $PINS Y=nx5253 A0=camera_module_cache_ram_23__1 A1=nx35172
+ S0=nx34640
Xix29354 aoi22 $PINS Y=nx29353 A0=camera_module_cache_ram_39__1 A1=nx35908
+ B0=camera_module_cache_ram_55__1 B1=nx35948
Xcamera_module_cache_reg_ram_39__1 dffr $PINS Q=camera_module_cache_ram_39__1
+ QB=#dummy[1168] D=nx5243 CLK=clk R=rst
Xix5244 mux21_ni $PINS Y=nx5243 A0=camera_module_cache_ram_39__1 A1=nx35172
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__1 dffr $PINS Q=camera_module_cache_ram_55__1
+ QB=#dummy[1169] D=nx5233 CLK=clk R=rst
Xix5234 mux21_ni $PINS Y=nx5233 A0=camera_module_cache_ram_55__1 A1=nx35172
+ S0=nx34632
Xix29362 aoi22 $PINS Y=nx29361 A0=camera_module_cache_ram_71__1 A1=nx35988
+ B0=camera_module_cache_ram_87__1 B1=nx36028
Xcamera_module_cache_reg_ram_71__1 dffr $PINS Q=camera_module_cache_ram_71__1
+ QB=#dummy[1170] D=nx5223 CLK=clk R=rst
Xix5224 mux21_ni $PINS Y=nx5223 A0=camera_module_cache_ram_71__1 A1=nx35172
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__1 dffr $PINS Q=camera_module_cache_ram_87__1
+ QB=#dummy[1171] D=nx5213 CLK=clk R=rst
Xix5214 mux21_ni $PINS Y=nx5213 A0=camera_module_cache_ram_87__1 A1=nx35172
+ S0=nx34624
Xix29370 aoi22 $PINS Y=nx29369 A0=camera_module_cache_ram_119__1 A1=nx36068
+ B0=camera_module_cache_ram_103__1 B1=nx36108
Xcamera_module_cache_reg_ram_119__1 dffr $PINS Q=camera_module_cache_ram_119__1
+ QB=#dummy[1172] D=nx5193 CLK=clk R=rst
Xix5194 mux21_ni $PINS Y=nx5193 A0=camera_module_cache_ram_119__1 A1=nx35172
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__1 dffr $PINS Q=camera_module_cache_ram_103__1
+ QB=#dummy[1173] D=nx5203 CLK=clk R=rst
Xix5204 mux21_ni $PINS Y=nx5203 A0=camera_module_cache_ram_103__1 A1=nx35174
+ S0=nx34620
Xix7489 nand04 $PINS Y=nx7488 A0=nx29378 A1=nx29386 A2=nx29394 A3=nx29402
Xix29379 aoi22 $PINS Y=nx29378 A0=camera_module_cache_ram_135__1 A1=nx36148
+ B0=camera_module_cache_ram_151__1 B1=nx36188
Xcamera_module_cache_reg_ram_135__1 dffr $PINS Q=camera_module_cache_ram_135__1
+ QB=#dummy[1174] D=nx5183 CLK=clk R=rst
Xix5184 mux21_ni $PINS Y=nx5183 A0=camera_module_cache_ram_135__1 A1=nx35174
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__1 dffr $PINS Q=camera_module_cache_ram_151__1
+ QB=#dummy[1175] D=nx5173 CLK=clk R=rst
Xix5174 mux21_ni $PINS Y=nx5173 A0=camera_module_cache_ram_151__1 A1=nx35174
+ S0=nx34608
Xix29387 aoi22 $PINS Y=nx29386 A0=camera_module_cache_ram_183__1 A1=nx36228
+ B0=camera_module_cache_ram_167__1 B1=nx36268
Xcamera_module_cache_reg_ram_183__1 dffr $PINS Q=camera_module_cache_ram_183__1
+ QB=#dummy[1176] D=nx5153 CLK=clk R=rst
Xix5154 mux21_ni $PINS Y=nx5153 A0=camera_module_cache_ram_183__1 A1=nx35174
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__1 dffr $PINS Q=camera_module_cache_ram_167__1
+ QB=#dummy[1177] D=nx5163 CLK=clk R=rst
Xix5164 mux21_ni $PINS Y=nx5163 A0=camera_module_cache_ram_167__1 A1=nx35174
+ S0=nx34604
Xix29395 aoi22 $PINS Y=nx29394 A0=camera_module_cache_ram_199__1 A1=nx36308
+ B0=camera_module_cache_ram_215__1 B1=nx36348
Xcamera_module_cache_reg_ram_199__1 dffr $PINS Q=camera_module_cache_ram_199__1
+ QB=#dummy[1178] D=nx5143 CLK=clk R=rst
Xix5144 mux21_ni $PINS Y=nx5143 A0=camera_module_cache_ram_199__1 A1=nx35174
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__1 dffr $PINS Q=camera_module_cache_ram_215__1
+ QB=#dummy[1179] D=nx5133 CLK=clk R=rst
Xix5134 mux21_ni $PINS Y=nx5133 A0=camera_module_cache_ram_215__1 A1=nx35174
+ S0=nx34592
Xix29403 aoi22 $PINS Y=nx29402 A0=camera_module_cache_ram_231__1 A1=nx36388
+ B0=camera_module_cache_ram_247__1 B1=nx36428
Xcamera_module_cache_reg_ram_231__1 dffr $PINS Q=camera_module_cache_ram_231__1
+ QB=#dummy[1180] D=nx5123 CLK=clk R=rst
Xix5124 mux21_ni $PINS Y=nx5123 A0=camera_module_cache_ram_231__1 A1=nx35176
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__1 dffr $PINS Q=camera_module_cache_ram_247__1
+ QB=#dummy[1181] D=nx5113 CLK=clk R=rst
Xix5114 mux21_ni $PINS Y=nx5113 A0=camera_module_cache_ram_247__1 A1=nx35176
+ S0=nx34584
Xix7409 nand04 $PINS Y=nx7408 A0=nx29411 A1=nx29479 A2=nx29547 A3=nx29615
Xix29412 oai21 $PINS Y=nx29411 A0=nx7398 A1=nx7320 B0=nx36480
Xix7399 nand04 $PINS Y=nx7398 A0=nx29414 A1=nx29422 A2=nx29430 A3=nx29438
Xix29415 aoi22 $PINS Y=nx29414 A0=camera_module_cache_ram_8__1 A1=nx35828
+ B0=camera_module_cache_ram_24__1 B1=nx35868
Xcamera_module_cache_reg_ram_8__1 dffr $PINS Q=camera_module_cache_ram_8__1
+ QB=#dummy[1182] D=nx5103 CLK=clk R=rst
Xix5104 mux21_ni $PINS Y=nx5103 A0=camera_module_cache_ram_8__1 A1=nx35176
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__1 dffr $PINS Q=camera_module_cache_ram_24__1
+ QB=#dummy[1183] D=nx5093 CLK=clk R=rst
Xix5094 mux21_ni $PINS Y=nx5093 A0=camera_module_cache_ram_24__1 A1=nx35176
+ S0=nx34570
Xix29423 aoi22 $PINS Y=nx29422 A0=camera_module_cache_ram_40__1 A1=nx35908
+ B0=camera_module_cache_ram_56__1 B1=nx35948
Xcamera_module_cache_reg_ram_40__1 dffr $PINS Q=camera_module_cache_ram_40__1
+ QB=#dummy[1184] D=nx5083 CLK=clk R=rst
Xix5084 mux21_ni $PINS Y=nx5083 A0=camera_module_cache_ram_40__1 A1=nx35176
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__1 dffr $PINS Q=camera_module_cache_ram_56__1
+ QB=#dummy[1185] D=nx5073 CLK=clk R=rst
Xix5074 mux21_ni $PINS Y=nx5073 A0=camera_module_cache_ram_56__1 A1=nx35176
+ S0=nx34562
Xix29431 aoi22 $PINS Y=nx29430 A0=camera_module_cache_ram_72__1 A1=nx35988
+ B0=camera_module_cache_ram_88__1 B1=nx36028
Xcamera_module_cache_reg_ram_72__1 dffr $PINS Q=camera_module_cache_ram_72__1
+ QB=#dummy[1186] D=nx5063 CLK=clk R=rst
Xix5064 mux21_ni $PINS Y=nx5063 A0=camera_module_cache_ram_72__1 A1=nx35176
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__1 dffr $PINS Q=camera_module_cache_ram_88__1
+ QB=#dummy[1187] D=nx5053 CLK=clk R=rst
Xix5054 mux21_ni $PINS Y=nx5053 A0=camera_module_cache_ram_88__1 A1=nx35178
+ S0=nx34554
Xix29439 aoi22 $PINS Y=nx29438 A0=camera_module_cache_ram_120__1 A1=nx36068
+ B0=camera_module_cache_ram_104__1 B1=nx36108
Xcamera_module_cache_reg_ram_120__1 dffr $PINS Q=camera_module_cache_ram_120__1
+ QB=#dummy[1188] D=nx5033 CLK=clk R=rst
Xix5034 mux21_ni $PINS Y=nx5033 A0=camera_module_cache_ram_120__1 A1=nx35178
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__1 dffr $PINS Q=camera_module_cache_ram_104__1
+ QB=#dummy[1189] D=nx5043 CLK=clk R=rst
Xix5044 mux21_ni $PINS Y=nx5043 A0=camera_module_cache_ram_104__1 A1=nx35178
+ S0=nx34550
Xix7321 nand04 $PINS Y=nx7320 A0=nx29447 A1=nx29455 A2=nx29463 A3=nx29471
Xix29448 aoi22 $PINS Y=nx29447 A0=camera_module_cache_ram_136__1 A1=nx36148
+ B0=camera_module_cache_ram_152__1 B1=nx36188
Xcamera_module_cache_reg_ram_136__1 dffr $PINS Q=camera_module_cache_ram_136__1
+ QB=#dummy[1190] D=nx5023 CLK=clk R=rst
Xix5024 mux21_ni $PINS Y=nx5023 A0=camera_module_cache_ram_136__1 A1=nx35178
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__1 dffr $PINS Q=camera_module_cache_ram_152__1
+ QB=#dummy[1191] D=nx5013 CLK=clk R=rst
Xix5014 mux21_ni $PINS Y=nx5013 A0=camera_module_cache_ram_152__1 A1=nx35178
+ S0=nx34538
Xix29456 aoi22 $PINS Y=nx29455 A0=camera_module_cache_ram_184__1 A1=nx36228
+ B0=camera_module_cache_ram_168__1 B1=nx36268
Xcamera_module_cache_reg_ram_184__1 dffr $PINS Q=camera_module_cache_ram_184__1
+ QB=#dummy[1192] D=nx4993 CLK=clk R=rst
Xix4994 mux21_ni $PINS Y=nx4993 A0=camera_module_cache_ram_184__1 A1=nx35178
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__1 dffr $PINS Q=camera_module_cache_ram_168__1
+ QB=#dummy[1193] D=nx5003 CLK=clk R=rst
Xix5004 mux21_ni $PINS Y=nx5003 A0=camera_module_cache_ram_168__1 A1=nx35178
+ S0=nx34534
Xix29464 aoi22 $PINS Y=nx29463 A0=camera_module_cache_ram_200__1 A1=nx36308
+ B0=camera_module_cache_ram_216__1 B1=nx36348
Xcamera_module_cache_reg_ram_200__1 dffr $PINS Q=camera_module_cache_ram_200__1
+ QB=#dummy[1194] D=nx4983 CLK=clk R=rst
Xix4984 mux21_ni $PINS Y=nx4983 A0=camera_module_cache_ram_200__1 A1=nx35180
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__1 dffr $PINS Q=camera_module_cache_ram_216__1
+ QB=#dummy[1195] D=nx4973 CLK=clk R=rst
Xix4974 mux21_ni $PINS Y=nx4973 A0=camera_module_cache_ram_216__1 A1=nx35180
+ S0=nx34522
Xix29472 aoi22 $PINS Y=nx29471 A0=camera_module_cache_ram_232__1 A1=nx36388
+ B0=camera_module_cache_ram_248__1 B1=nx36428
Xcamera_module_cache_reg_ram_232__1 dffr $PINS Q=camera_module_cache_ram_232__1
+ QB=#dummy[1196] D=nx4963 CLK=clk R=rst
Xix4964 mux21_ni $PINS Y=nx4963 A0=camera_module_cache_ram_232__1 A1=nx35180
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__1 dffr $PINS Q=camera_module_cache_ram_248__1
+ QB=#dummy[1197] D=nx4953 CLK=clk R=rst
Xix4954 mux21_ni $PINS Y=nx4953 A0=camera_module_cache_ram_248__1 A1=nx35180
+ S0=nx34514
Xix29480 oai21 $PINS Y=nx29479 A0=nx7236 A1=nx7158 B0=nx36484
Xix7237 nand04 $PINS Y=nx7236 A0=nx29482 A1=nx29490 A2=nx29498 A3=nx29506
Xix29483 aoi22 $PINS Y=nx29482 A0=camera_module_cache_ram_9__1 A1=nx35830
+ B0=camera_module_cache_ram_25__1 B1=nx35870
Xcamera_module_cache_reg_ram_9__1 dffr $PINS Q=camera_module_cache_ram_9__1
+ QB=#dummy[1198] D=nx4943 CLK=clk R=rst
Xix4944 mux21_ni $PINS Y=nx4943 A0=camera_module_cache_ram_9__1 A1=nx35180
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__1 dffr $PINS Q=camera_module_cache_ram_25__1
+ QB=#dummy[1199] D=nx4933 CLK=clk R=rst
Xix4934 mux21_ni $PINS Y=nx4933 A0=camera_module_cache_ram_25__1 A1=nx35180
+ S0=nx34500
Xix29491 aoi22 $PINS Y=nx29490 A0=camera_module_cache_ram_41__1 A1=nx35910
+ B0=camera_module_cache_ram_57__1 B1=nx35950
Xcamera_module_cache_reg_ram_41__1 dffr $PINS Q=camera_module_cache_ram_41__1
+ QB=#dummy[1200] D=nx4923 CLK=clk R=rst
Xix4924 mux21_ni $PINS Y=nx4923 A0=camera_module_cache_ram_41__1 A1=nx35180
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__1 dffr $PINS Q=camera_module_cache_ram_57__1
+ QB=#dummy[1201] D=nx4913 CLK=clk R=rst
Xix4914 mux21_ni $PINS Y=nx4913 A0=camera_module_cache_ram_57__1 A1=nx35182
+ S0=nx34492
Xix29499 aoi22 $PINS Y=nx29498 A0=camera_module_cache_ram_73__1 A1=nx35990
+ B0=camera_module_cache_ram_89__1 B1=nx36030
Xcamera_module_cache_reg_ram_73__1 dffr $PINS Q=camera_module_cache_ram_73__1
+ QB=#dummy[1202] D=nx4903 CLK=clk R=rst
Xix4904 mux21_ni $PINS Y=nx4903 A0=camera_module_cache_ram_73__1 A1=nx35182
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__1 dffr $PINS Q=camera_module_cache_ram_89__1
+ QB=#dummy[1203] D=nx4893 CLK=clk R=rst
Xix4894 mux21_ni $PINS Y=nx4893 A0=camera_module_cache_ram_89__1 A1=nx35182
+ S0=nx34484
Xix29507 aoi22 $PINS Y=nx29506 A0=camera_module_cache_ram_121__1 A1=nx36070
+ B0=camera_module_cache_ram_105__1 B1=nx36110
Xcamera_module_cache_reg_ram_121__1 dffr $PINS Q=camera_module_cache_ram_121__1
+ QB=#dummy[1204] D=nx4873 CLK=clk R=rst
Xix4874 mux21_ni $PINS Y=nx4873 A0=camera_module_cache_ram_121__1 A1=nx35182
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__1 dffr $PINS Q=camera_module_cache_ram_105__1
+ QB=#dummy[1205] D=nx4883 CLK=clk R=rst
Xix4884 mux21_ni $PINS Y=nx4883 A0=camera_module_cache_ram_105__1 A1=nx35182
+ S0=nx34480
Xix7159 nand04 $PINS Y=nx7158 A0=nx29515 A1=nx29523 A2=nx29531 A3=nx29539
Xix29516 aoi22 $PINS Y=nx29515 A0=camera_module_cache_ram_137__1 A1=nx36150
+ B0=camera_module_cache_ram_153__1 B1=nx36190
Xcamera_module_cache_reg_ram_137__1 dffr $PINS Q=camera_module_cache_ram_137__1
+ QB=#dummy[1206] D=nx4863 CLK=clk R=rst
Xix4864 mux21_ni $PINS Y=nx4863 A0=camera_module_cache_ram_137__1 A1=nx35182
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__1 dffr $PINS Q=camera_module_cache_ram_153__1
+ QB=#dummy[1207] D=nx4853 CLK=clk R=rst
Xix4854 mux21_ni $PINS Y=nx4853 A0=camera_module_cache_ram_153__1 A1=nx35182
+ S0=nx34468
Xix29524 aoi22 $PINS Y=nx29523 A0=camera_module_cache_ram_185__1 A1=nx36230
+ B0=camera_module_cache_ram_169__1 B1=nx36270
Xcamera_module_cache_reg_ram_185__1 dffr $PINS Q=camera_module_cache_ram_185__1
+ QB=#dummy[1208] D=nx4833 CLK=clk R=rst
Xix4834 mux21_ni $PINS Y=nx4833 A0=camera_module_cache_ram_185__1 A1=nx35184
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__1 dffr $PINS Q=camera_module_cache_ram_169__1
+ QB=#dummy[1209] D=nx4843 CLK=clk R=rst
Xix4844 mux21_ni $PINS Y=nx4843 A0=camera_module_cache_ram_169__1 A1=nx35184
+ S0=nx34464
Xix29532 aoi22 $PINS Y=nx29531 A0=camera_module_cache_ram_201__1 A1=nx36310
+ B0=camera_module_cache_ram_217__1 B1=nx36350
Xcamera_module_cache_reg_ram_201__1 dffr $PINS Q=camera_module_cache_ram_201__1
+ QB=#dummy[1210] D=nx4823 CLK=clk R=rst
Xix4824 mux21_ni $PINS Y=nx4823 A0=camera_module_cache_ram_201__1 A1=nx35184
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__1 dffr $PINS Q=camera_module_cache_ram_217__1
+ QB=#dummy[1211] D=nx4813 CLK=clk R=rst
Xix4814 mux21_ni $PINS Y=nx4813 A0=camera_module_cache_ram_217__1 A1=nx35184
+ S0=nx34452
Xix29540 aoi22 $PINS Y=nx29539 A0=camera_module_cache_ram_233__1 A1=nx36390
+ B0=camera_module_cache_ram_249__1 B1=nx36430
Xcamera_module_cache_reg_ram_233__1 dffr $PINS Q=camera_module_cache_ram_233__1
+ QB=#dummy[1212] D=nx4803 CLK=clk R=rst
Xix4804 mux21_ni $PINS Y=nx4803 A0=camera_module_cache_ram_233__1 A1=nx35184
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__1 dffr $PINS Q=camera_module_cache_ram_249__1
+ QB=#dummy[1213] D=nx4793 CLK=clk R=rst
Xix4794 mux21_ni $PINS Y=nx4793 A0=camera_module_cache_ram_249__1 A1=nx35184
+ S0=nx34444
Xix29548 oai21 $PINS Y=nx29547 A0=nx7072 A1=nx6994 B0=nx36488
Xix7073 nand04 $PINS Y=nx7072 A0=nx29550 A1=nx29558 A2=nx29566 A3=nx29574
Xix29551 aoi22 $PINS Y=nx29550 A0=camera_module_cache_ram_10__1 A1=nx35830
+ B0=camera_module_cache_ram_26__1 B1=nx35870
Xcamera_module_cache_reg_ram_10__1 dffr $PINS Q=camera_module_cache_ram_10__1
+ QB=#dummy[1214] D=nx4783 CLK=clk R=rst
Xix4784 mux21_ni $PINS Y=nx4783 A0=camera_module_cache_ram_10__1 A1=nx35184
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__1 dffr $PINS Q=camera_module_cache_ram_26__1
+ QB=#dummy[1215] D=nx4773 CLK=clk R=rst
Xix4774 mux21_ni $PINS Y=nx4773 A0=camera_module_cache_ram_26__1 A1=nx35186
+ S0=nx34430
Xix29559 aoi22 $PINS Y=nx29558 A0=camera_module_cache_ram_42__1 A1=nx35910
+ B0=camera_module_cache_ram_58__1 B1=nx35950
Xcamera_module_cache_reg_ram_42__1 dffr $PINS Q=camera_module_cache_ram_42__1
+ QB=#dummy[1216] D=nx4763 CLK=clk R=rst
Xix4764 mux21_ni $PINS Y=nx4763 A0=camera_module_cache_ram_42__1 A1=nx35186
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__1 dffr $PINS Q=camera_module_cache_ram_58__1
+ QB=#dummy[1217] D=nx4753 CLK=clk R=rst
Xix4754 mux21_ni $PINS Y=nx4753 A0=camera_module_cache_ram_58__1 A1=nx35186
+ S0=nx34422
Xix29567 aoi22 $PINS Y=nx29566 A0=camera_module_cache_ram_74__1 A1=nx35990
+ B0=camera_module_cache_ram_90__1 B1=nx36030
Xcamera_module_cache_reg_ram_74__1 dffr $PINS Q=camera_module_cache_ram_74__1
+ QB=#dummy[1218] D=nx4743 CLK=clk R=rst
Xix4744 mux21_ni $PINS Y=nx4743 A0=camera_module_cache_ram_74__1 A1=nx35186
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__1 dffr $PINS Q=camera_module_cache_ram_90__1
+ QB=#dummy[1219] D=nx4733 CLK=clk R=rst
Xix4734 mux21_ni $PINS Y=nx4733 A0=camera_module_cache_ram_90__1 A1=nx35186
+ S0=nx34414
Xix29575 aoi22 $PINS Y=nx29574 A0=camera_module_cache_ram_122__1 A1=nx36070
+ B0=camera_module_cache_ram_106__1 B1=nx36110
Xcamera_module_cache_reg_ram_122__1 dffr $PINS Q=camera_module_cache_ram_122__1
+ QB=#dummy[1220] D=nx4713 CLK=clk R=rst
Xix4714 mux21_ni $PINS Y=nx4713 A0=camera_module_cache_ram_122__1 A1=nx35186
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__1 dffr $PINS Q=camera_module_cache_ram_106__1
+ QB=#dummy[1221] D=nx4723 CLK=clk R=rst
Xix4724 mux21_ni $PINS Y=nx4723 A0=camera_module_cache_ram_106__1 A1=nx35186
+ S0=nx34410
Xix6995 nand04 $PINS Y=nx6994 A0=nx29583 A1=nx29591 A2=nx29599 A3=nx29607
Xix29584 aoi22 $PINS Y=nx29583 A0=camera_module_cache_ram_138__1 A1=nx36150
+ B0=camera_module_cache_ram_154__1 B1=nx36190
Xcamera_module_cache_reg_ram_138__1 dffr $PINS Q=camera_module_cache_ram_138__1
+ QB=#dummy[1222] D=nx4703 CLK=clk R=rst
Xix4704 mux21_ni $PINS Y=nx4703 A0=camera_module_cache_ram_138__1 A1=nx35188
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__1 dffr $PINS Q=camera_module_cache_ram_154__1
+ QB=#dummy[1223] D=nx4693 CLK=clk R=rst
Xix4694 mux21_ni $PINS Y=nx4693 A0=camera_module_cache_ram_154__1 A1=nx35188
+ S0=nx34398
Xix29592 aoi22 $PINS Y=nx29591 A0=camera_module_cache_ram_186__1 A1=nx36230
+ B0=camera_module_cache_ram_170__1 B1=nx36270
Xcamera_module_cache_reg_ram_186__1 dffr $PINS Q=camera_module_cache_ram_186__1
+ QB=#dummy[1224] D=nx4673 CLK=clk R=rst
Xix4674 mux21_ni $PINS Y=nx4673 A0=camera_module_cache_ram_186__1 A1=nx35188
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__1 dffr $PINS Q=camera_module_cache_ram_170__1
+ QB=#dummy[1225] D=nx4683 CLK=clk R=rst
Xix4684 mux21_ni $PINS Y=nx4683 A0=camera_module_cache_ram_170__1 A1=nx35188
+ S0=nx34394
Xix29600 aoi22 $PINS Y=nx29599 A0=camera_module_cache_ram_202__1 A1=nx36310
+ B0=camera_module_cache_ram_218__1 B1=nx36350
Xcamera_module_cache_reg_ram_202__1 dffr $PINS Q=camera_module_cache_ram_202__1
+ QB=#dummy[1226] D=nx4663 CLK=clk R=rst
Xix4664 mux21_ni $PINS Y=nx4663 A0=camera_module_cache_ram_202__1 A1=nx35188
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__1 dffr $PINS Q=camera_module_cache_ram_218__1
+ QB=#dummy[1227] D=nx4653 CLK=clk R=rst
Xix4654 mux21_ni $PINS Y=nx4653 A0=camera_module_cache_ram_218__1 A1=nx35188
+ S0=nx34382
Xix29608 aoi22 $PINS Y=nx29607 A0=camera_module_cache_ram_234__1 A1=nx36390
+ B0=camera_module_cache_ram_250__1 B1=nx36430
Xcamera_module_cache_reg_ram_234__1 dffr $PINS Q=camera_module_cache_ram_234__1
+ QB=#dummy[1228] D=nx4643 CLK=clk R=rst
Xix4644 mux21_ni $PINS Y=nx4643 A0=camera_module_cache_ram_234__1 A1=nx35188
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__1 dffr $PINS Q=camera_module_cache_ram_250__1
+ QB=#dummy[1229] D=nx4633 CLK=clk R=rst
Xix4634 mux21_ni $PINS Y=nx4633 A0=camera_module_cache_ram_250__1 A1=nx35190
+ S0=nx34374
Xix29616 oai21 $PINS Y=nx29615 A0=nx6910 A1=nx6832 B0=nx36492
Xix6911 nand04 $PINS Y=nx6910 A0=nx29618 A1=nx29626 A2=nx29634 A3=nx29642
Xix29619 aoi22 $PINS Y=nx29618 A0=camera_module_cache_ram_11__1 A1=nx35830
+ B0=camera_module_cache_ram_27__1 B1=nx35870
Xcamera_module_cache_reg_ram_11__1 dffr $PINS Q=camera_module_cache_ram_11__1
+ QB=#dummy[1230] D=nx4623 CLK=clk R=rst
Xix4624 mux21_ni $PINS Y=nx4623 A0=camera_module_cache_ram_11__1 A1=nx35190
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__1 dffr $PINS Q=camera_module_cache_ram_27__1
+ QB=#dummy[1231] D=nx4613 CLK=clk R=rst
Xix4614 mux21_ni $PINS Y=nx4613 A0=camera_module_cache_ram_27__1 A1=nx35190
+ S0=nx34360
Xix29627 aoi22 $PINS Y=nx29626 A0=camera_module_cache_ram_43__1 A1=nx35910
+ B0=camera_module_cache_ram_59__1 B1=nx35950
Xcamera_module_cache_reg_ram_43__1 dffr $PINS Q=camera_module_cache_ram_43__1
+ QB=#dummy[1232] D=nx4603 CLK=clk R=rst
Xix4604 mux21_ni $PINS Y=nx4603 A0=camera_module_cache_ram_43__1 A1=nx35190
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__1 dffr $PINS Q=camera_module_cache_ram_59__1
+ QB=#dummy[1233] D=nx4593 CLK=clk R=rst
Xix4594 mux21_ni $PINS Y=nx4593 A0=camera_module_cache_ram_59__1 A1=nx35190
+ S0=nx34352
Xix29635 aoi22 $PINS Y=nx29634 A0=camera_module_cache_ram_75__1 A1=nx35990
+ B0=camera_module_cache_ram_91__1 B1=nx36030
Xcamera_module_cache_reg_ram_75__1 dffr $PINS Q=camera_module_cache_ram_75__1
+ QB=#dummy[1234] D=nx4583 CLK=clk R=rst
Xix4584 mux21_ni $PINS Y=nx4583 A0=camera_module_cache_ram_75__1 A1=nx35190
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__1 dffr $PINS Q=camera_module_cache_ram_91__1
+ QB=#dummy[1235] D=nx4573 CLK=clk R=rst
Xix4574 mux21_ni $PINS Y=nx4573 A0=camera_module_cache_ram_91__1 A1=nx35190
+ S0=nx34344
Xix29643 aoi22 $PINS Y=nx29642 A0=camera_module_cache_ram_123__1 A1=nx36070
+ B0=camera_module_cache_ram_107__1 B1=nx36110
Xcamera_module_cache_reg_ram_123__1 dffr $PINS Q=camera_module_cache_ram_123__1
+ QB=#dummy[1236] D=nx4553 CLK=clk R=rst
Xix4554 mux21_ni $PINS Y=nx4553 A0=camera_module_cache_ram_123__1 A1=nx35192
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__1 dffr $PINS Q=camera_module_cache_ram_107__1
+ QB=#dummy[1237] D=nx4563 CLK=clk R=rst
Xix4564 mux21_ni $PINS Y=nx4563 A0=camera_module_cache_ram_107__1 A1=nx35192
+ S0=nx34340
Xix6833 nand04 $PINS Y=nx6832 A0=nx29651 A1=nx29659 A2=nx29667 A3=nx29675
Xix29652 aoi22 $PINS Y=nx29651 A0=camera_module_cache_ram_139__1 A1=nx36150
+ B0=camera_module_cache_ram_155__1 B1=nx36190
Xcamera_module_cache_reg_ram_139__1 dffr $PINS Q=camera_module_cache_ram_139__1
+ QB=#dummy[1238] D=nx4543 CLK=clk R=rst
Xix4544 mux21_ni $PINS Y=nx4543 A0=camera_module_cache_ram_139__1 A1=nx35192
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__1 dffr $PINS Q=camera_module_cache_ram_155__1
+ QB=#dummy[1239] D=nx4533 CLK=clk R=rst
Xix4534 mux21_ni $PINS Y=nx4533 A0=camera_module_cache_ram_155__1 A1=nx35192
+ S0=nx34328
Xix29660 aoi22 $PINS Y=nx29659 A0=camera_module_cache_ram_187__1 A1=nx36230
+ B0=camera_module_cache_ram_171__1 B1=nx36270
Xcamera_module_cache_reg_ram_187__1 dffr $PINS Q=camera_module_cache_ram_187__1
+ QB=#dummy[1240] D=nx4513 CLK=clk R=rst
Xix4514 mux21_ni $PINS Y=nx4513 A0=camera_module_cache_ram_187__1 A1=nx35192
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__1 dffr $PINS Q=camera_module_cache_ram_171__1
+ QB=#dummy[1241] D=nx4523 CLK=clk R=rst
Xix4524 mux21_ni $PINS Y=nx4523 A0=camera_module_cache_ram_171__1 A1=nx35192
+ S0=nx34324
Xix29668 aoi22 $PINS Y=nx29667 A0=camera_module_cache_ram_203__1 A1=nx36310
+ B0=camera_module_cache_ram_219__1 B1=nx36350
Xcamera_module_cache_reg_ram_203__1 dffr $PINS Q=camera_module_cache_ram_203__1
+ QB=#dummy[1242] D=nx4503 CLK=clk R=rst
Xix4504 mux21_ni $PINS Y=nx4503 A0=camera_module_cache_ram_203__1 A1=nx35192
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__1 dffr $PINS Q=camera_module_cache_ram_219__1
+ QB=#dummy[1243] D=nx4493 CLK=clk R=rst
Xix4494 mux21_ni $PINS Y=nx4493 A0=camera_module_cache_ram_219__1 A1=nx35194
+ S0=nx34312
Xix29676 aoi22 $PINS Y=nx29675 A0=camera_module_cache_ram_235__1 A1=nx36390
+ B0=camera_module_cache_ram_251__1 B1=nx36430
Xcamera_module_cache_reg_ram_235__1 dffr $PINS Q=camera_module_cache_ram_235__1
+ QB=#dummy[1244] D=nx4483 CLK=clk R=rst
Xix4484 mux21_ni $PINS Y=nx4483 A0=camera_module_cache_ram_235__1 A1=nx35194
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__1 dffr $PINS Q=camera_module_cache_ram_251__1
+ QB=#dummy[1245] D=nx4473 CLK=clk R=rst
Xix4474 mux21_ni $PINS Y=nx4473 A0=camera_module_cache_ram_251__1 A1=nx35194
+ S0=nx34304
Xix6755 nand04 $PINS Y=nx6754 A0=nx29684 A1=nx29752 A2=nx29820 A3=nx29888
Xix29685 oai21 $PINS Y=nx29684 A0=nx6744 A1=nx6666 B0=nx36506
Xix6745 nand04 $PINS Y=nx6744 A0=nx29687 A1=nx29695 A2=nx29703 A3=nx29711
Xix29688 aoi22 $PINS Y=nx29687 A0=camera_module_cache_ram_12__1 A1=nx35830
+ B0=camera_module_cache_ram_28__1 B1=nx35870
Xcamera_module_cache_reg_ram_12__1 dffr $PINS Q=camera_module_cache_ram_12__1
+ QB=#dummy[1246] D=nx4463 CLK=clk R=rst
Xix4464 mux21_ni $PINS Y=nx4463 A0=nx35194 A1=camera_module_cache_ram_12__1
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__1 dffr $PINS Q=camera_module_cache_ram_28__1
+ QB=#dummy[1247] D=nx4453 CLK=clk R=rst
Xix4454 mux21_ni $PINS Y=nx4453 A0=nx35194 A1=camera_module_cache_ram_28__1
+ S0=nx36510
Xix29696 aoi22 $PINS Y=nx29695 A0=camera_module_cache_ram_44__1 A1=nx35910
+ B0=camera_module_cache_ram_60__1 B1=nx35950
Xcamera_module_cache_reg_ram_44__1 dffr $PINS Q=camera_module_cache_ram_44__1
+ QB=#dummy[1248] D=nx4443 CLK=clk R=rst
Xix4444 mux21_ni $PINS Y=nx4443 A0=nx35194 A1=camera_module_cache_ram_44__1
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__1 dffr $PINS Q=camera_module_cache_ram_60__1
+ QB=#dummy[1249] D=nx4433 CLK=clk R=rst
Xix4434 mux21_ni $PINS Y=nx4433 A0=nx35194 A1=camera_module_cache_ram_60__1
+ S0=nx36518
Xix29704 aoi22 $PINS Y=nx29703 A0=camera_module_cache_ram_76__1 A1=nx35990
+ B0=camera_module_cache_ram_92__1 B1=nx36030
Xcamera_module_cache_reg_ram_76__1 dffr $PINS Q=camera_module_cache_ram_76__1
+ QB=#dummy[1250] D=nx4423 CLK=clk R=rst
Xix4424 mux21_ni $PINS Y=nx4423 A0=nx35196 A1=camera_module_cache_ram_76__1
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__1 dffr $PINS Q=camera_module_cache_ram_92__1
+ QB=#dummy[1251] D=nx4413 CLK=clk R=rst
Xix4414 mux21_ni $PINS Y=nx4413 A0=nx35196 A1=camera_module_cache_ram_92__1
+ S0=nx36526
Xix29712 aoi22 $PINS Y=nx29711 A0=camera_module_cache_ram_124__1 A1=nx36070
+ B0=camera_module_cache_ram_108__1 B1=nx36110
Xcamera_module_cache_reg_ram_124__1 dffr $PINS Q=camera_module_cache_ram_124__1
+ QB=#dummy[1252] D=nx4393 CLK=clk R=rst
Xix4394 mux21_ni $PINS Y=nx4393 A0=nx35196 A1=camera_module_cache_ram_124__1
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__1 dffr $PINS Q=camera_module_cache_ram_108__1
+ QB=#dummy[1253] D=nx4403 CLK=clk R=rst
Xix4404 mux21_ni $PINS Y=nx4403 A0=nx35196 A1=camera_module_cache_ram_108__1
+ S0=nx36534
Xix6667 nand04 $PINS Y=nx6666 A0=nx29720 A1=nx29728 A2=nx29736 A3=nx29744
Xix29721 aoi22 $PINS Y=nx29720 A0=camera_module_cache_ram_140__1 A1=nx36150
+ B0=camera_module_cache_ram_156__1 B1=nx36190
Xcamera_module_cache_reg_ram_140__1 dffr $PINS Q=camera_module_cache_ram_140__1
+ QB=#dummy[1254] D=nx4383 CLK=clk R=rst
Xix4384 mux21_ni $PINS Y=nx4383 A0=nx35196 A1=camera_module_cache_ram_140__1
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__1 dffr $PINS Q=camera_module_cache_ram_156__1
+ QB=#dummy[1255] D=nx4373 CLK=clk R=rst
Xix4374 mux21_ni $PINS Y=nx4373 A0=nx35196 A1=camera_module_cache_ram_156__1
+ S0=nx36542
Xix29729 aoi22 $PINS Y=nx29728 A0=camera_module_cache_ram_188__1 A1=nx36230
+ B0=camera_module_cache_ram_172__1 B1=nx36270
Xcamera_module_cache_reg_ram_188__1 dffr $PINS Q=camera_module_cache_ram_188__1
+ QB=#dummy[1256] D=nx4353 CLK=clk R=rst
Xix4354 mux21_ni $PINS Y=nx4353 A0=nx35196 A1=camera_module_cache_ram_188__1
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__1 dffr $PINS Q=camera_module_cache_ram_172__1
+ QB=#dummy[1257] D=nx4363 CLK=clk R=rst
Xix4364 mux21_ni $PINS Y=nx4363 A0=nx35198 A1=camera_module_cache_ram_172__1
+ S0=nx36550
Xix29737 aoi22 $PINS Y=nx29736 A0=camera_module_cache_ram_204__1 A1=nx36310
+ B0=camera_module_cache_ram_220__1 B1=nx36350
Xcamera_module_cache_reg_ram_204__1 dffr $PINS Q=camera_module_cache_ram_204__1
+ QB=#dummy[1258] D=nx4343 CLK=clk R=rst
Xix4344 mux21_ni $PINS Y=nx4343 A0=nx35198 A1=camera_module_cache_ram_204__1
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__1 dffr $PINS Q=camera_module_cache_ram_220__1
+ QB=#dummy[1259] D=nx4333 CLK=clk R=rst
Xix4334 mux21_ni $PINS Y=nx4333 A0=nx35198 A1=camera_module_cache_ram_220__1
+ S0=nx36558
Xix29745 aoi22 $PINS Y=nx29744 A0=camera_module_cache_ram_236__1 A1=nx36390
+ B0=camera_module_cache_ram_252__1 B1=nx36430
Xcamera_module_cache_reg_ram_236__1 dffr $PINS Q=camera_module_cache_ram_236__1
+ QB=#dummy[1260] D=nx4323 CLK=clk R=rst
Xix4324 mux21_ni $PINS Y=nx4323 A0=nx35198 A1=camera_module_cache_ram_236__1
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__1 dffr $PINS Q=camera_module_cache_ram_252__1
+ QB=#dummy[1261] D=nx4313 CLK=clk R=rst
Xix4314 mux21_ni $PINS Y=nx4313 A0=nx35198 A1=camera_module_cache_ram_252__1
+ S0=nx36566
Xix29753 oai21 $PINS Y=nx29752 A0=nx6582 A1=nx6504 B0=nx36580
Xix6583 nand04 $PINS Y=nx6582 A0=nx29755 A1=nx29763 A2=nx29771 A3=nx29779
Xix29756 aoi22 $PINS Y=nx29755 A0=camera_module_cache_ram_13__1 A1=nx35830
+ B0=camera_module_cache_ram_29__1 B1=nx35870
Xcamera_module_cache_reg_ram_13__1 dffr $PINS Q=camera_module_cache_ram_13__1
+ QB=#dummy[1262] D=nx4303 CLK=clk R=rst
Xix4304 mux21_ni $PINS Y=nx4303 A0=nx35198 A1=camera_module_cache_ram_13__1
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__1 dffr $PINS Q=camera_module_cache_ram_29__1
+ QB=#dummy[1263] D=nx4293 CLK=clk R=rst
Xix4294 mux21_ni $PINS Y=nx4293 A0=nx35198 A1=camera_module_cache_ram_29__1
+ S0=nx36584
Xix29764 aoi22 $PINS Y=nx29763 A0=camera_module_cache_ram_45__1 A1=nx35910
+ B0=camera_module_cache_ram_61__1 B1=nx35950
Xcamera_module_cache_reg_ram_45__1 dffr $PINS Q=camera_module_cache_ram_45__1
+ QB=#dummy[1264] D=nx4283 CLK=clk R=rst
Xix4284 mux21_ni $PINS Y=nx4283 A0=nx35200 A1=camera_module_cache_ram_45__1
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__1 dffr $PINS Q=camera_module_cache_ram_61__1
+ QB=#dummy[1265] D=nx4273 CLK=clk R=rst
Xix4274 mux21_ni $PINS Y=nx4273 A0=nx35200 A1=camera_module_cache_ram_61__1
+ S0=nx36592
Xix29772 aoi22 $PINS Y=nx29771 A0=camera_module_cache_ram_77__1 A1=nx35990
+ B0=camera_module_cache_ram_93__1 B1=nx36030
Xcamera_module_cache_reg_ram_77__1 dffr $PINS Q=camera_module_cache_ram_77__1
+ QB=#dummy[1266] D=nx4263 CLK=clk R=rst
Xix4264 mux21_ni $PINS Y=nx4263 A0=nx35200 A1=camera_module_cache_ram_77__1
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__1 dffr $PINS Q=camera_module_cache_ram_93__1
+ QB=#dummy[1267] D=nx4253 CLK=clk R=rst
Xix4254 mux21_ni $PINS Y=nx4253 A0=nx35200 A1=camera_module_cache_ram_93__1
+ S0=nx36600
Xix29780 aoi22 $PINS Y=nx29779 A0=camera_module_cache_ram_125__1 A1=nx36070
+ B0=camera_module_cache_ram_109__1 B1=nx36110
Xcamera_module_cache_reg_ram_125__1 dffr $PINS Q=camera_module_cache_ram_125__1
+ QB=#dummy[1268] D=nx4233 CLK=clk R=rst
Xix4234 mux21_ni $PINS Y=nx4233 A0=nx35200 A1=camera_module_cache_ram_125__1
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__1 dffr $PINS Q=camera_module_cache_ram_109__1
+ QB=#dummy[1269] D=nx4243 CLK=clk R=rst
Xix4244 mux21_ni $PINS Y=nx4243 A0=nx35200 A1=camera_module_cache_ram_109__1
+ S0=nx36608
Xix6505 nand04 $PINS Y=nx6504 A0=nx29788 A1=nx29796 A2=nx29804 A3=nx29812
Xix29789 aoi22 $PINS Y=nx29788 A0=camera_module_cache_ram_141__1 A1=nx36150
+ B0=camera_module_cache_ram_157__1 B1=nx36190
Xcamera_module_cache_reg_ram_141__1 dffr $PINS Q=camera_module_cache_ram_141__1
+ QB=#dummy[1270] D=nx4223 CLK=clk R=rst
Xix4224 mux21_ni $PINS Y=nx4223 A0=nx35200 A1=camera_module_cache_ram_141__1
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__1 dffr $PINS Q=camera_module_cache_ram_157__1
+ QB=#dummy[1271] D=nx4213 CLK=clk R=rst
Xix4214 mux21_ni $PINS Y=nx4213 A0=nx35202 A1=camera_module_cache_ram_157__1
+ S0=nx36616
Xix29797 aoi22 $PINS Y=nx29796 A0=camera_module_cache_ram_189__1 A1=nx36230
+ B0=camera_module_cache_ram_173__1 B1=nx36270
Xcamera_module_cache_reg_ram_189__1 dffr $PINS Q=camera_module_cache_ram_189__1
+ QB=#dummy[1272] D=nx4193 CLK=clk R=rst
Xix4194 mux21_ni $PINS Y=nx4193 A0=nx35202 A1=camera_module_cache_ram_189__1
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__1 dffr $PINS Q=camera_module_cache_ram_173__1
+ QB=#dummy[1273] D=nx4203 CLK=clk R=rst
Xix4204 mux21_ni $PINS Y=nx4203 A0=nx35202 A1=camera_module_cache_ram_173__1
+ S0=nx36624
Xix29805 aoi22 $PINS Y=nx29804 A0=camera_module_cache_ram_205__1 A1=nx36310
+ B0=camera_module_cache_ram_221__1 B1=nx36350
Xcamera_module_cache_reg_ram_205__1 dffr $PINS Q=camera_module_cache_ram_205__1
+ QB=#dummy[1274] D=nx4183 CLK=clk R=rst
Xix4184 mux21_ni $PINS Y=nx4183 A0=nx35202 A1=camera_module_cache_ram_205__1
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__1 dffr $PINS Q=camera_module_cache_ram_221__1
+ QB=#dummy[1275] D=nx4173 CLK=clk R=rst
Xix4174 mux21_ni $PINS Y=nx4173 A0=nx35202 A1=camera_module_cache_ram_221__1
+ S0=nx36632
Xix29813 aoi22 $PINS Y=nx29812 A0=camera_module_cache_ram_237__1 A1=nx36390
+ B0=camera_module_cache_ram_253__1 B1=nx36430
Xcamera_module_cache_reg_ram_237__1 dffr $PINS Q=camera_module_cache_ram_237__1
+ QB=#dummy[1276] D=nx4163 CLK=clk R=rst
Xix4164 mux21_ni $PINS Y=nx4163 A0=nx35202 A1=camera_module_cache_ram_237__1
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__1 dffr $PINS Q=camera_module_cache_ram_253__1
+ QB=#dummy[1277] D=nx4153 CLK=clk R=rst
Xix4154 mux21_ni $PINS Y=nx4153 A0=nx35202 A1=camera_module_cache_ram_253__1
+ S0=nx36640
Xix29821 oai21 $PINS Y=nx29820 A0=nx6418 A1=nx6340 B0=nx36654
Xix6419 nand04 $PINS Y=nx6418 A0=nx29823 A1=nx29831 A2=nx29839 A3=nx29847
Xix29824 aoi22 $PINS Y=nx29823 A0=camera_module_cache_ram_14__1 A1=nx35830
+ B0=camera_module_cache_ram_30__1 B1=nx35870
Xcamera_module_cache_reg_ram_14__1 dffr $PINS Q=camera_module_cache_ram_14__1
+ QB=#dummy[1278] D=nx4143 CLK=clk R=rst
Xix4144 mux21_ni $PINS Y=nx4143 A0=nx35204 A1=camera_module_cache_ram_14__1
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__1 dffr $PINS Q=camera_module_cache_ram_30__1
+ QB=#dummy[1279] D=nx4133 CLK=clk R=rst
Xix4134 mux21_ni $PINS Y=nx4133 A0=nx35204 A1=camera_module_cache_ram_30__1
+ S0=nx36658
Xix29832 aoi22 $PINS Y=nx29831 A0=camera_module_cache_ram_46__1 A1=nx35910
+ B0=camera_module_cache_ram_62__1 B1=nx35950
Xcamera_module_cache_reg_ram_46__1 dffr $PINS Q=camera_module_cache_ram_46__1
+ QB=#dummy[1280] D=nx4123 CLK=clk R=rst
Xix4124 mux21_ni $PINS Y=nx4123 A0=nx35204 A1=camera_module_cache_ram_46__1
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__1 dffr $PINS Q=camera_module_cache_ram_62__1
+ QB=#dummy[1281] D=nx4113 CLK=clk R=rst
Xix4114 mux21_ni $PINS Y=nx4113 A0=nx35204 A1=camera_module_cache_ram_62__1
+ S0=nx36666
Xix29840 aoi22 $PINS Y=nx29839 A0=camera_module_cache_ram_78__1 A1=nx35990
+ B0=camera_module_cache_ram_94__1 B1=nx36030
Xcamera_module_cache_reg_ram_78__1 dffr $PINS Q=camera_module_cache_ram_78__1
+ QB=#dummy[1282] D=nx4103 CLK=clk R=rst
Xix4104 mux21_ni $PINS Y=nx4103 A0=nx35204 A1=camera_module_cache_ram_78__1
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__1 dffr $PINS Q=camera_module_cache_ram_94__1
+ QB=#dummy[1283] D=nx4093 CLK=clk R=rst
Xix4094 mux21_ni $PINS Y=nx4093 A0=nx35204 A1=camera_module_cache_ram_94__1
+ S0=nx36674
Xix29848 aoi22 $PINS Y=nx29847 A0=camera_module_cache_ram_126__1 A1=nx36070
+ B0=camera_module_cache_ram_110__1 B1=nx36110
Xcamera_module_cache_reg_ram_126__1 dffr $PINS Q=camera_module_cache_ram_126__1
+ QB=#dummy[1284] D=nx4073 CLK=clk R=rst
Xix4074 mux21_ni $PINS Y=nx4073 A0=nx35204 A1=camera_module_cache_ram_126__1
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__1 dffr $PINS Q=camera_module_cache_ram_110__1
+ QB=#dummy[1285] D=nx4083 CLK=clk R=rst
Xix4084 mux21_ni $PINS Y=nx4083 A0=nx35206 A1=camera_module_cache_ram_110__1
+ S0=nx36682
Xix6341 nand04 $PINS Y=nx6340 A0=nx29856 A1=nx29864 A2=nx29872 A3=nx29880
Xix29857 aoi22 $PINS Y=nx29856 A0=camera_module_cache_ram_142__1 A1=nx36150
+ B0=camera_module_cache_ram_158__1 B1=nx36190
Xcamera_module_cache_reg_ram_142__1 dffr $PINS Q=camera_module_cache_ram_142__1
+ QB=#dummy[1286] D=nx4063 CLK=clk R=rst
Xix4064 mux21_ni $PINS Y=nx4063 A0=nx35206 A1=camera_module_cache_ram_142__1
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__1 dffr $PINS Q=camera_module_cache_ram_158__1
+ QB=#dummy[1287] D=nx4053 CLK=clk R=rst
Xix4054 mux21_ni $PINS Y=nx4053 A0=nx35206 A1=camera_module_cache_ram_158__1
+ S0=nx36690
Xix29865 aoi22 $PINS Y=nx29864 A0=camera_module_cache_ram_190__1 A1=nx36230
+ B0=camera_module_cache_ram_174__1 B1=nx36270
Xcamera_module_cache_reg_ram_190__1 dffr $PINS Q=camera_module_cache_ram_190__1
+ QB=#dummy[1288] D=nx4033 CLK=clk R=rst
Xix4034 mux21_ni $PINS Y=nx4033 A0=nx35206 A1=camera_module_cache_ram_190__1
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__1 dffr $PINS Q=camera_module_cache_ram_174__1
+ QB=#dummy[1289] D=nx4043 CLK=clk R=rst
Xix4044 mux21_ni $PINS Y=nx4043 A0=nx35206 A1=camera_module_cache_ram_174__1
+ S0=nx36698
Xix29873 aoi22 $PINS Y=nx29872 A0=camera_module_cache_ram_206__1 A1=nx36310
+ B0=camera_module_cache_ram_222__1 B1=nx36350
Xcamera_module_cache_reg_ram_206__1 dffr $PINS Q=camera_module_cache_ram_206__1
+ QB=#dummy[1290] D=nx4023 CLK=clk R=rst
Xix4024 mux21_ni $PINS Y=nx4023 A0=nx35206 A1=camera_module_cache_ram_206__1
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__1 dffr $PINS Q=camera_module_cache_ram_222__1
+ QB=#dummy[1291] D=nx4013 CLK=clk R=rst
Xix4014 mux21_ni $PINS Y=nx4013 A0=nx35206 A1=camera_module_cache_ram_222__1
+ S0=nx36706
Xix29881 aoi22 $PINS Y=nx29880 A0=camera_module_cache_ram_238__1 A1=nx36390
+ B0=camera_module_cache_ram_254__1 B1=nx36430
Xcamera_module_cache_reg_ram_238__1 dffr $PINS Q=camera_module_cache_ram_238__1
+ QB=#dummy[1292] D=nx4003 CLK=clk R=rst
Xix4004 mux21_ni $PINS Y=nx4003 A0=nx35208 A1=camera_module_cache_ram_238__1
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__1 dffr $PINS Q=camera_module_cache_ram_254__1
+ QB=#dummy[1293] D=nx3993 CLK=clk R=rst
Xix3994 mux21_ni $PINS Y=nx3993 A0=nx35208 A1=camera_module_cache_ram_254__1
+ S0=nx36714
Xix29889 oai21 $PINS Y=nx29888 A0=nx6256 A1=nx6178 B0=nx36728
Xix6257 nand04 $PINS Y=nx6256 A0=nx29891 A1=nx29899 A2=nx29907 A3=nx29915
Xix29892 aoi22 $PINS Y=nx29891 A0=camera_module_cache_ram_15__1 A1=nx35830
+ B0=camera_module_cache_ram_31__1 B1=nx35870
Xcamera_module_cache_reg_ram_15__1 dffr $PINS Q=camera_module_cache_ram_15__1
+ QB=#dummy[1294] D=nx3983 CLK=clk R=rst
Xix3984 mux21_ni $PINS Y=nx3983 A0=nx35208 A1=camera_module_cache_ram_15__1
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__1 dffr $PINS Q=camera_module_cache_ram_31__1
+ QB=#dummy[1295] D=nx3973 CLK=clk R=rst
Xix3974 mux21_ni $PINS Y=nx3973 A0=nx35208 A1=camera_module_cache_ram_31__1
+ S0=nx36732
Xix29900 aoi22 $PINS Y=nx29899 A0=camera_module_cache_ram_47__1 A1=nx35910
+ B0=camera_module_cache_ram_63__1 B1=nx35950
Xcamera_module_cache_reg_ram_47__1 dffr $PINS Q=camera_module_cache_ram_47__1
+ QB=#dummy[1296] D=nx3963 CLK=clk R=rst
Xix3964 mux21_ni $PINS Y=nx3963 A0=nx35208 A1=camera_module_cache_ram_47__1
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__1 dffr $PINS Q=camera_module_cache_ram_63__1
+ QB=#dummy[1297] D=nx3953 CLK=clk R=rst
Xix3954 mux21_ni $PINS Y=nx3953 A0=nx35208 A1=camera_module_cache_ram_63__1
+ S0=nx36740
Xix29908 aoi22 $PINS Y=nx29907 A0=camera_module_cache_ram_79__1 A1=nx35990
+ B0=camera_module_cache_ram_95__1 B1=nx36030
Xcamera_module_cache_reg_ram_79__1 dffr $PINS Q=camera_module_cache_ram_79__1
+ QB=#dummy[1298] D=nx3943 CLK=clk R=rst
Xix3944 mux21_ni $PINS Y=nx3943 A0=nx35208 A1=camera_module_cache_ram_79__1
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__1 dffr $PINS Q=camera_module_cache_ram_95__1
+ QB=#dummy[1299] D=nx3933 CLK=clk R=rst
Xix3934 mux21_ni $PINS Y=nx3933 A0=nx35210 A1=camera_module_cache_ram_95__1
+ S0=nx36748
Xix29916 aoi22 $PINS Y=nx29915 A0=camera_module_cache_ram_127__1 A1=nx36070
+ B0=camera_module_cache_ram_111__1 B1=nx36110
Xcamera_module_cache_reg_ram_127__1 dffr $PINS Q=camera_module_cache_ram_127__1
+ QB=#dummy[1300] D=nx3913 CLK=clk R=rst
Xix3914 mux21_ni $PINS Y=nx3913 A0=nx35210 A1=camera_module_cache_ram_127__1
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__1 dffr $PINS Q=camera_module_cache_ram_111__1
+ QB=#dummy[1301] D=nx3923 CLK=clk R=rst
Xix3924 mux21_ni $PINS Y=nx3923 A0=nx35210 A1=camera_module_cache_ram_111__1
+ S0=nx36756
Xix6179 nand04 $PINS Y=nx6178 A0=nx29924 A1=nx29932 A2=nx29940 A3=nx29948
Xix29925 aoi22 $PINS Y=nx29924 A0=camera_module_cache_ram_143__1 A1=nx36150
+ B0=camera_module_cache_ram_159__1 B1=nx36190
Xcamera_module_cache_reg_ram_143__1 dffr $PINS Q=camera_module_cache_ram_143__1
+ QB=#dummy[1302] D=nx3903 CLK=clk R=rst
Xix3904 mux21_ni $PINS Y=nx3903 A0=nx35210 A1=camera_module_cache_ram_143__1
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__1 dffr $PINS Q=camera_module_cache_ram_159__1
+ QB=#dummy[1303] D=nx3893 CLK=clk R=rst
Xix3894 mux21_ni $PINS Y=nx3893 A0=nx35210 A1=camera_module_cache_ram_159__1
+ S0=nx36764
Xix29933 aoi22 $PINS Y=nx29932 A0=camera_module_cache_ram_191__1 A1=nx36230
+ B0=camera_module_cache_ram_175__1 B1=nx36270
Xcamera_module_cache_reg_ram_191__1 dffr $PINS Q=camera_module_cache_ram_191__1
+ QB=#dummy[1304] D=nx3873 CLK=clk R=rst
Xix3874 mux21_ni $PINS Y=nx3873 A0=nx35210 A1=camera_module_cache_ram_191__1
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__1 dffr $PINS Q=camera_module_cache_ram_175__1
+ QB=#dummy[1305] D=nx3883 CLK=clk R=rst
Xix3884 mux21_ni $PINS Y=nx3883 A0=nx35210 A1=camera_module_cache_ram_175__1
+ S0=nx36772
Xix29941 aoi22 $PINS Y=nx29940 A0=camera_module_cache_ram_207__1 A1=nx36310
+ B0=camera_module_cache_ram_223__1 B1=nx36350
Xcamera_module_cache_reg_ram_207__1 dffr $PINS Q=camera_module_cache_ram_207__1
+ QB=#dummy[1306] D=nx3863 CLK=clk R=rst
Xix3864 mux21_ni $PINS Y=nx3863 A0=nx35212 A1=camera_module_cache_ram_207__1
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__1 dffr $PINS Q=camera_module_cache_ram_223__1
+ QB=#dummy[1307] D=nx3853 CLK=clk R=rst
Xix3854 mux21_ni $PINS Y=nx3853 A0=nx35212 A1=camera_module_cache_ram_223__1
+ S0=nx36780
Xix29949 aoi22 $PINS Y=nx29948 A0=camera_module_cache_ram_239__1 A1=nx36390
+ B0=camera_module_cache_ram_255__1 B1=nx36430
Xcamera_module_cache_reg_ram_239__1 dffr $PINS Q=camera_module_cache_ram_239__1
+ QB=#dummy[1308] D=nx3843 CLK=clk R=rst
Xix3844 mux21_ni $PINS Y=nx3843 A0=nx35212 A1=camera_module_cache_ram_239__1
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__1 dffr $PINS Q=camera_module_cache_ram_255__1
+ QB=#dummy[1309] D=nx3833 CLK=clk R=rst
Xix3834 mux21_ni $PINS Y=nx3833 A0=nx35212 A1=camera_module_cache_ram_255__1
+ S0=nx36788
Xcamera_module_algo_module_pixel_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_pixel_value_3 QB=nx31098 D=nx11533 CLK=clk
Xix11534 mux21_ni $PINS Y=nx11533 A0=nx14286
+ A1=camera_module_algo_module_pixel_value_3 S0=nx22665
Xix29965 mux21_ni $PINS Y=nx29964 A0=nx29966 A1=nx35676 S0=nx36792
Xix29967 nor04 $PINS Y=nx29966 A0=nx14266 A1=nx13612 A2=nx12956 A3=nx12302
Xix14267 nand04 $PINS Y=nx14266 A0=nx29969 A1=nx30075 A2=nx30143 A3=nx30211
Xix29970 oai21 $PINS Y=nx29969 A0=nx14256 A1=nx14178 B0=nx36448
Xix14257 nand04 $PINS Y=nx14256 A0=nx29972 A1=nx30018 A2=nx30026 A3=nx30034
Xix29973 aoi22 $PINS Y=nx29972 A0=camera_module_cache_ram_0__3 A1=nx35832
+ B0=camera_module_cache_ram_16__3 B1=nx35872
Xcamera_module_cache_reg_ram_0__3 dffr $PINS Q=camera_module_cache_ram_0__3
+ QB=#dummy[1310] D=nx11523 CLK=clk R=rst
Xix11524 mux21_ni $PINS Y=nx11523 A0=camera_module_cache_ram_0__3 A1=nx35292
+ S0=nx35134
Xix11649 oai221 $PINS Y=nx11648 A0=nx34076 A1=nx29977 B0=nx29993 B1=nx35714
+ C0=nx29996
Xnvm_module_tri_dataout_123 tri01 $PINS Y=nvm_data_123 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_115 tri01 $PINS Y=nvm_data_115 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_107 tri01 $PINS Y=nvm_data_107 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_99 tri01 $PINS Y=nvm_data_99 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_91 tri01 $PINS Y=nvm_data_91 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_83 tri01 $PINS Y=nvm_data_83 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_75 tri01 $PINS Y=nvm_data_75 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_67 tri01 $PINS Y=nvm_data_67 A=nx22549
+ E=nvm_module_GND0
Xix29994 inv01 $PINS Y=nx29993 A=nvm_data_3
Xnvm_module_tri_dataout_3 tri01 $PINS Y=nvm_data_3 A=nx22549 E=nvm_module_GND0
Xix29997 nand02 $PINS Y=nx29996 A0=nx34076 A1=nx11582
Xnvm_module_tri_dataout_59 tri01 $PINS Y=nvm_data_59 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_51 tri01 $PINS Y=nvm_data_51 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_43 tri01 $PINS Y=nvm_data_43 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_35 tri01 $PINS Y=nvm_data_35 A=nx22549
+ E=nvm_module_GND0
Xix11551 oai22 $PINS Y=nx11550 A0=nx34106 A1=nx30007 B0=nx34092 B1=nx30011
Xnvm_module_tri_dataout_27 tri01 $PINS Y=nvm_data_27 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_19 tri01 $PINS Y=nvm_data_19 A=nx22549
+ E=nvm_module_GND0
Xix30012 nand02 $PINS Y=nx30011 A0=nvm_data_11 A1=nx34106
Xnvm_module_tri_dataout_11 tri01 $PINS Y=nvm_data_11 A=nx22549
+ E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__3 dffr $PINS Q=camera_module_cache_ram_16__3
+ QB=#dummy[1311] D=nx11513 CLK=clk R=rst
Xix11514 mux21_ni $PINS Y=nx11513 A0=camera_module_cache_ram_16__3 A1=nx35292
+ S0=nx35130
Xix30019 aoi22 $PINS Y=nx30018 A0=camera_module_cache_ram_32__3 A1=nx35912
+ B0=camera_module_cache_ram_48__3 B1=nx35952
Xcamera_module_cache_reg_ram_32__3 dffr $PINS Q=camera_module_cache_ram_32__3
+ QB=#dummy[1312] D=nx11503 CLK=clk R=rst
Xix11504 mux21_ni $PINS Y=nx11503 A0=camera_module_cache_ram_32__3 A1=nx35292
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__3 dffr $PINS Q=camera_module_cache_ram_48__3
+ QB=#dummy[1313] D=nx11493 CLK=clk R=rst
Xix11494 mux21_ni $PINS Y=nx11493 A0=camera_module_cache_ram_48__3 A1=nx35292
+ S0=nx35122
Xix30027 aoi22 $PINS Y=nx30026 A0=camera_module_cache_ram_64__3 A1=nx35992
+ B0=camera_module_cache_ram_80__3 B1=nx36032
Xcamera_module_cache_reg_ram_64__3 dffr $PINS Q=camera_module_cache_ram_64__3
+ QB=#dummy[1314] D=nx11483 CLK=clk R=rst
Xix11484 mux21_ni $PINS Y=nx11483 A0=camera_module_cache_ram_64__3 A1=nx35292
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__3 dffr $PINS Q=camera_module_cache_ram_80__3
+ QB=#dummy[1315] D=nx11473 CLK=clk R=rst
Xix11474 mux21_ni $PINS Y=nx11473 A0=camera_module_cache_ram_80__3 A1=nx35292
+ S0=nx35114
Xix30035 aoi22 $PINS Y=nx30034 A0=camera_module_cache_ram_112__3 A1=nx36072
+ B0=camera_module_cache_ram_96__3 B1=nx36112
Xcamera_module_cache_reg_ram_112__3 dffr $PINS Q=camera_module_cache_ram_112__3
+ QB=#dummy[1316] D=nx11453 CLK=clk R=rst
Xix11454 mux21_ni $PINS Y=nx11453 A0=camera_module_cache_ram_112__3 A1=nx35292
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__3 dffr $PINS Q=camera_module_cache_ram_96__3
+ QB=#dummy[1317] D=nx11463 CLK=clk R=rst
Xix11464 mux21_ni $PINS Y=nx11463 A0=camera_module_cache_ram_96__3 A1=nx35294
+ S0=nx35110
Xix14179 nand04 $PINS Y=nx14178 A0=nx30043 A1=nx30051 A2=nx30059 A3=nx30067
Xix30044 aoi22 $PINS Y=nx30043 A0=camera_module_cache_ram_128__3 A1=nx36152
+ B0=camera_module_cache_ram_144__3 B1=nx36192
Xcamera_module_cache_reg_ram_128__3 dffr $PINS Q=camera_module_cache_ram_128__3
+ QB=#dummy[1318] D=nx11443 CLK=clk R=rst
Xix11444 mux21_ni $PINS Y=nx11443 A0=camera_module_cache_ram_128__3 A1=nx35294
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__3 dffr $PINS Q=camera_module_cache_ram_144__3
+ QB=#dummy[1319] D=nx11433 CLK=clk R=rst
Xix11434 mux21_ni $PINS Y=nx11433 A0=camera_module_cache_ram_144__3 A1=nx35294
+ S0=nx35098
Xix30052 aoi22 $PINS Y=nx30051 A0=camera_module_cache_ram_176__3 A1=nx36232
+ B0=camera_module_cache_ram_160__3 B1=nx36272
Xcamera_module_cache_reg_ram_176__3 dffr $PINS Q=camera_module_cache_ram_176__3
+ QB=#dummy[1320] D=nx11413 CLK=clk R=rst
Xix11414 mux21_ni $PINS Y=nx11413 A0=camera_module_cache_ram_176__3 A1=nx35294
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__3 dffr $PINS Q=camera_module_cache_ram_160__3
+ QB=#dummy[1321] D=nx11423 CLK=clk R=rst
Xix11424 mux21_ni $PINS Y=nx11423 A0=camera_module_cache_ram_160__3 A1=nx35294
+ S0=nx35094
Xix30060 aoi22 $PINS Y=nx30059 A0=camera_module_cache_ram_192__3 A1=nx36312
+ B0=camera_module_cache_ram_208__3 B1=nx36352
Xcamera_module_cache_reg_ram_192__3 dffr $PINS Q=camera_module_cache_ram_192__3
+ QB=#dummy[1322] D=nx11403 CLK=clk R=rst
Xix11404 mux21_ni $PINS Y=nx11403 A0=camera_module_cache_ram_192__3 A1=nx35294
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__3 dffr $PINS Q=camera_module_cache_ram_208__3
+ QB=#dummy[1323] D=nx11393 CLK=clk R=rst
Xix11394 mux21_ni $PINS Y=nx11393 A0=camera_module_cache_ram_208__3 A1=nx35294
+ S0=nx35082
Xix30068 aoi22 $PINS Y=nx30067 A0=camera_module_cache_ram_224__3 A1=nx36392
+ B0=camera_module_cache_ram_240__3 B1=nx36432
Xcamera_module_cache_reg_ram_224__3 dffr $PINS Q=camera_module_cache_ram_224__3
+ QB=#dummy[1324] D=nx11383 CLK=clk R=rst
Xix11384 mux21_ni $PINS Y=nx11383 A0=camera_module_cache_ram_224__3 A1=nx35296
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__3 dffr $PINS Q=camera_module_cache_ram_240__3
+ QB=#dummy[1325] D=nx11373 CLK=clk R=rst
Xix11374 mux21_ni $PINS Y=nx11373 A0=camera_module_cache_ram_240__3 A1=nx35296
+ S0=nx35074
Xix30076 oai21 $PINS Y=nx30075 A0=nx14094 A1=nx14016 B0=nx36452
Xix14095 nand04 $PINS Y=nx14094 A0=nx30078 A1=nx30086 A2=nx30094 A3=nx30102
Xix30079 aoi22 $PINS Y=nx30078 A0=camera_module_cache_ram_1__3 A1=nx35832
+ B0=camera_module_cache_ram_17__3 B1=nx35872
Xcamera_module_cache_reg_ram_1__3 dffr $PINS Q=camera_module_cache_ram_1__3
+ QB=#dummy[1326] D=nx11363 CLK=clk R=rst
Xix11364 mux21_ni $PINS Y=nx11363 A0=camera_module_cache_ram_1__3 A1=nx35296
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__3 dffr $PINS Q=camera_module_cache_ram_17__3
+ QB=#dummy[1327] D=nx11353 CLK=clk R=rst
Xix11354 mux21_ni $PINS Y=nx11353 A0=camera_module_cache_ram_17__3 A1=nx35296
+ S0=nx35060
Xix30087 aoi22 $PINS Y=nx30086 A0=camera_module_cache_ram_33__3 A1=nx35912
+ B0=camera_module_cache_ram_49__3 B1=nx35952
Xcamera_module_cache_reg_ram_33__3 dffr $PINS Q=camera_module_cache_ram_33__3
+ QB=#dummy[1328] D=nx11343 CLK=clk R=rst
Xix11344 mux21_ni $PINS Y=nx11343 A0=camera_module_cache_ram_33__3 A1=nx35296
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__3 dffr $PINS Q=camera_module_cache_ram_49__3
+ QB=#dummy[1329] D=nx11333 CLK=clk R=rst
Xix11334 mux21_ni $PINS Y=nx11333 A0=camera_module_cache_ram_49__3 A1=nx35296
+ S0=nx35052
Xix30095 aoi22 $PINS Y=nx30094 A0=camera_module_cache_ram_65__3 A1=nx35992
+ B0=camera_module_cache_ram_81__3 B1=nx36032
Xcamera_module_cache_reg_ram_65__3 dffr $PINS Q=camera_module_cache_ram_65__3
+ QB=#dummy[1330] D=nx11323 CLK=clk R=rst
Xix11324 mux21_ni $PINS Y=nx11323 A0=camera_module_cache_ram_65__3 A1=nx35296
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__3 dffr $PINS Q=camera_module_cache_ram_81__3
+ QB=#dummy[1331] D=nx11313 CLK=clk R=rst
Xix11314 mux21_ni $PINS Y=nx11313 A0=camera_module_cache_ram_81__3 A1=nx35298
+ S0=nx35044
Xix30103 aoi22 $PINS Y=nx30102 A0=camera_module_cache_ram_113__3 A1=nx36072
+ B0=camera_module_cache_ram_97__3 B1=nx36112
Xcamera_module_cache_reg_ram_113__3 dffr $PINS Q=camera_module_cache_ram_113__3
+ QB=#dummy[1332] D=nx11293 CLK=clk R=rst
Xix11294 mux21_ni $PINS Y=nx11293 A0=camera_module_cache_ram_113__3 A1=nx35298
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__3 dffr $PINS Q=camera_module_cache_ram_97__3
+ QB=#dummy[1333] D=nx11303 CLK=clk R=rst
Xix11304 mux21_ni $PINS Y=nx11303 A0=camera_module_cache_ram_97__3 A1=nx35298
+ S0=nx35040
Xix14017 nand04 $PINS Y=nx14016 A0=nx30111 A1=nx30119 A2=nx30127 A3=nx30135
Xix30112 aoi22 $PINS Y=nx30111 A0=camera_module_cache_ram_129__3 A1=nx36152
+ B0=camera_module_cache_ram_145__3 B1=nx36192
Xcamera_module_cache_reg_ram_129__3 dffr $PINS Q=camera_module_cache_ram_129__3
+ QB=#dummy[1334] D=nx11283 CLK=clk R=rst
Xix11284 mux21_ni $PINS Y=nx11283 A0=camera_module_cache_ram_129__3 A1=nx35298
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__3 dffr $PINS Q=camera_module_cache_ram_145__3
+ QB=#dummy[1335] D=nx11273 CLK=clk R=rst
Xix11274 mux21_ni $PINS Y=nx11273 A0=camera_module_cache_ram_145__3 A1=nx35298
+ S0=nx35028
Xix30120 aoi22 $PINS Y=nx30119 A0=camera_module_cache_ram_177__3 A1=nx36232
+ B0=camera_module_cache_ram_161__3 B1=nx36272
Xcamera_module_cache_reg_ram_177__3 dffr $PINS Q=camera_module_cache_ram_177__3
+ QB=#dummy[1336] D=nx11253 CLK=clk R=rst
Xix11254 mux21_ni $PINS Y=nx11253 A0=camera_module_cache_ram_177__3 A1=nx35298
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__3 dffr $PINS Q=camera_module_cache_ram_161__3
+ QB=#dummy[1337] D=nx11263 CLK=clk R=rst
Xix11264 mux21_ni $PINS Y=nx11263 A0=camera_module_cache_ram_161__3 A1=nx35298
+ S0=nx35024
Xix30128 aoi22 $PINS Y=nx30127 A0=camera_module_cache_ram_193__3 A1=nx36312
+ B0=camera_module_cache_ram_209__3 B1=nx36352
Xcamera_module_cache_reg_ram_193__3 dffr $PINS Q=camera_module_cache_ram_193__3
+ QB=#dummy[1338] D=nx11243 CLK=clk R=rst
Xix11244 mux21_ni $PINS Y=nx11243 A0=camera_module_cache_ram_193__3 A1=nx35300
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__3 dffr $PINS Q=camera_module_cache_ram_209__3
+ QB=#dummy[1339] D=nx11233 CLK=clk R=rst
Xix11234 mux21_ni $PINS Y=nx11233 A0=camera_module_cache_ram_209__3 A1=nx35300
+ S0=nx35012
Xix30136 aoi22 $PINS Y=nx30135 A0=camera_module_cache_ram_225__3 A1=nx36392
+ B0=camera_module_cache_ram_241__3 B1=nx36432
Xcamera_module_cache_reg_ram_225__3 dffr $PINS Q=camera_module_cache_ram_225__3
+ QB=#dummy[1340] D=nx11223 CLK=clk R=rst
Xix11224 mux21_ni $PINS Y=nx11223 A0=camera_module_cache_ram_225__3 A1=nx35300
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__3 dffr $PINS Q=camera_module_cache_ram_241__3
+ QB=#dummy[1341] D=nx11213 CLK=clk R=rst
Xix11214 mux21_ni $PINS Y=nx11213 A0=camera_module_cache_ram_241__3 A1=nx35300
+ S0=nx35004
Xix30144 oai21 $PINS Y=nx30143 A0=nx13930 A1=nx13852 B0=nx36456
Xix13931 nand04 $PINS Y=nx13930 A0=nx30146 A1=nx30154 A2=nx30162 A3=nx30170
Xix30147 aoi22 $PINS Y=nx30146 A0=camera_module_cache_ram_2__3 A1=nx35832
+ B0=camera_module_cache_ram_18__3 B1=nx35872
Xcamera_module_cache_reg_ram_2__3 dffr $PINS Q=camera_module_cache_ram_2__3
+ QB=#dummy[1342] D=nx11203 CLK=clk R=rst
Xix11204 mux21_ni $PINS Y=nx11203 A0=camera_module_cache_ram_2__3 A1=nx35300
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__3 dffr $PINS Q=camera_module_cache_ram_18__3
+ QB=#dummy[1343] D=nx11193 CLK=clk R=rst
Xix11194 mux21_ni $PINS Y=nx11193 A0=camera_module_cache_ram_18__3 A1=nx35300
+ S0=nx34990
Xix30155 aoi22 $PINS Y=nx30154 A0=camera_module_cache_ram_34__3 A1=nx35912
+ B0=camera_module_cache_ram_50__3 B1=nx35952
Xcamera_module_cache_reg_ram_34__3 dffr $PINS Q=camera_module_cache_ram_34__3
+ QB=#dummy[1344] D=nx11183 CLK=clk R=rst
Xix11184 mux21_ni $PINS Y=nx11183 A0=camera_module_cache_ram_34__3 A1=nx35300
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__3 dffr $PINS Q=camera_module_cache_ram_50__3
+ QB=#dummy[1345] D=nx11173 CLK=clk R=rst
Xix11174 mux21_ni $PINS Y=nx11173 A0=camera_module_cache_ram_50__3 A1=nx35302
+ S0=nx34982
Xix30163 aoi22 $PINS Y=nx30162 A0=camera_module_cache_ram_66__3 A1=nx35992
+ B0=camera_module_cache_ram_82__3 B1=nx36032
Xcamera_module_cache_reg_ram_66__3 dffr $PINS Q=camera_module_cache_ram_66__3
+ QB=#dummy[1346] D=nx11163 CLK=clk R=rst
Xix11164 mux21_ni $PINS Y=nx11163 A0=camera_module_cache_ram_66__3 A1=nx35302
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__3 dffr $PINS Q=camera_module_cache_ram_82__3
+ QB=#dummy[1347] D=nx11153 CLK=clk R=rst
Xix11154 mux21_ni $PINS Y=nx11153 A0=camera_module_cache_ram_82__3 A1=nx35302
+ S0=nx34974
Xix30171 aoi22 $PINS Y=nx30170 A0=camera_module_cache_ram_114__3 A1=nx36072
+ B0=camera_module_cache_ram_98__3 B1=nx36112
Xcamera_module_cache_reg_ram_114__3 dffr $PINS Q=camera_module_cache_ram_114__3
+ QB=#dummy[1348] D=nx11133 CLK=clk R=rst
Xix11134 mux21_ni $PINS Y=nx11133 A0=camera_module_cache_ram_114__3 A1=nx35302
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__3 dffr $PINS Q=camera_module_cache_ram_98__3
+ QB=#dummy[1349] D=nx11143 CLK=clk R=rst
Xix11144 mux21_ni $PINS Y=nx11143 A0=camera_module_cache_ram_98__3 A1=nx35302
+ S0=nx34970
Xix13853 nand04 $PINS Y=nx13852 A0=nx30179 A1=nx30187 A2=nx30195 A3=nx30203
Xix30180 aoi22 $PINS Y=nx30179 A0=camera_module_cache_ram_130__3 A1=nx36152
+ B0=camera_module_cache_ram_146__3 B1=nx36192
Xcamera_module_cache_reg_ram_130__3 dffr $PINS Q=camera_module_cache_ram_130__3
+ QB=#dummy[1350] D=nx11123 CLK=clk R=rst
Xix11124 mux21_ni $PINS Y=nx11123 A0=camera_module_cache_ram_130__3 A1=nx35302
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__3 dffr $PINS Q=camera_module_cache_ram_146__3
+ QB=#dummy[1351] D=nx11113 CLK=clk R=rst
Xix11114 mux21_ni $PINS Y=nx11113 A0=camera_module_cache_ram_146__3 A1=nx35302
+ S0=nx34958
Xix30188 aoi22 $PINS Y=nx30187 A0=camera_module_cache_ram_178__3 A1=nx36232
+ B0=camera_module_cache_ram_162__3 B1=nx36272
Xcamera_module_cache_reg_ram_178__3 dffr $PINS Q=camera_module_cache_ram_178__3
+ QB=#dummy[1352] D=nx11093 CLK=clk R=rst
Xix11094 mux21_ni $PINS Y=nx11093 A0=camera_module_cache_ram_178__3 A1=nx35304
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__3 dffr $PINS Q=camera_module_cache_ram_162__3
+ QB=#dummy[1353] D=nx11103 CLK=clk R=rst
Xix11104 mux21_ni $PINS Y=nx11103 A0=camera_module_cache_ram_162__3 A1=nx35304
+ S0=nx34954
Xix30196 aoi22 $PINS Y=nx30195 A0=camera_module_cache_ram_194__3 A1=nx36312
+ B0=camera_module_cache_ram_210__3 B1=nx36352
Xcamera_module_cache_reg_ram_194__3 dffr $PINS Q=camera_module_cache_ram_194__3
+ QB=#dummy[1354] D=nx11083 CLK=clk R=rst
Xix11084 mux21_ni $PINS Y=nx11083 A0=camera_module_cache_ram_194__3 A1=nx35304
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__3 dffr $PINS Q=camera_module_cache_ram_210__3
+ QB=#dummy[1355] D=nx11073 CLK=clk R=rst
Xix11074 mux21_ni $PINS Y=nx11073 A0=camera_module_cache_ram_210__3 A1=nx35304
+ S0=nx34942
Xix30204 aoi22 $PINS Y=nx30203 A0=camera_module_cache_ram_226__3 A1=nx36392
+ B0=camera_module_cache_ram_242__3 B1=nx36432
Xcamera_module_cache_reg_ram_226__3 dffr $PINS Q=camera_module_cache_ram_226__3
+ QB=#dummy[1356] D=nx11063 CLK=clk R=rst
Xix11064 mux21_ni $PINS Y=nx11063 A0=camera_module_cache_ram_226__3 A1=nx35304
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__3 dffr $PINS Q=camera_module_cache_ram_242__3
+ QB=#dummy[1357] D=nx11053 CLK=clk R=rst
Xix11054 mux21_ni $PINS Y=nx11053 A0=camera_module_cache_ram_242__3 A1=nx35304
+ S0=nx34934
Xix30212 oai21 $PINS Y=nx30211 A0=nx13768 A1=nx13690 B0=nx36460
Xix13769 nand04 $PINS Y=nx13768 A0=nx30214 A1=nx30222 A2=nx30230 A3=nx30238
Xix30215 aoi22 $PINS Y=nx30214 A0=camera_module_cache_ram_3__3 A1=nx35832
+ B0=camera_module_cache_ram_19__3 B1=nx35872
Xcamera_module_cache_reg_ram_3__3 dffr $PINS Q=camera_module_cache_ram_3__3
+ QB=#dummy[1358] D=nx11043 CLK=clk R=rst
Xix11044 mux21_ni $PINS Y=nx11043 A0=camera_module_cache_ram_3__3 A1=nx35304
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__3 dffr $PINS Q=camera_module_cache_ram_19__3
+ QB=#dummy[1359] D=nx11033 CLK=clk R=rst
Xix11034 mux21_ni $PINS Y=nx11033 A0=camera_module_cache_ram_19__3 A1=nx35306
+ S0=nx34920
Xix30223 aoi22 $PINS Y=nx30222 A0=camera_module_cache_ram_35__3 A1=nx35912
+ B0=camera_module_cache_ram_51__3 B1=nx35952
Xcamera_module_cache_reg_ram_35__3 dffr $PINS Q=camera_module_cache_ram_35__3
+ QB=#dummy[1360] D=nx11023 CLK=clk R=rst
Xix11024 mux21_ni $PINS Y=nx11023 A0=camera_module_cache_ram_35__3 A1=nx35306
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__3 dffr $PINS Q=camera_module_cache_ram_51__3
+ QB=#dummy[1361] D=nx11013 CLK=clk R=rst
Xix11014 mux21_ni $PINS Y=nx11013 A0=camera_module_cache_ram_51__3 A1=nx35306
+ S0=nx34912
Xix30231 aoi22 $PINS Y=nx30230 A0=camera_module_cache_ram_67__3 A1=nx35992
+ B0=camera_module_cache_ram_83__3 B1=nx36032
Xcamera_module_cache_reg_ram_67__3 dffr $PINS Q=camera_module_cache_ram_67__3
+ QB=#dummy[1362] D=nx11003 CLK=clk R=rst
Xix11004 mux21_ni $PINS Y=nx11003 A0=camera_module_cache_ram_67__3 A1=nx35306
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__3 dffr $PINS Q=camera_module_cache_ram_83__3
+ QB=#dummy[1363] D=nx10993 CLK=clk R=rst
Xix10994 mux21_ni $PINS Y=nx10993 A0=camera_module_cache_ram_83__3 A1=nx35306
+ S0=nx34904
Xix30239 aoi22 $PINS Y=nx30238 A0=camera_module_cache_ram_115__3 A1=nx36072
+ B0=camera_module_cache_ram_99__3 B1=nx36112
Xcamera_module_cache_reg_ram_115__3 dffr $PINS Q=camera_module_cache_ram_115__3
+ QB=#dummy[1364] D=nx10973 CLK=clk R=rst
Xix10974 mux21_ni $PINS Y=nx10973 A0=camera_module_cache_ram_115__3 A1=nx35306
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__3 dffr $PINS Q=camera_module_cache_ram_99__3
+ QB=#dummy[1365] D=nx10983 CLK=clk R=rst
Xix10984 mux21_ni $PINS Y=nx10983 A0=camera_module_cache_ram_99__3 A1=nx35306
+ S0=nx34900
Xix13691 nand04 $PINS Y=nx13690 A0=nx30247 A1=nx30255 A2=nx30263 A3=nx30271
Xix30248 aoi22 $PINS Y=nx30247 A0=camera_module_cache_ram_131__3 A1=nx36152
+ B0=camera_module_cache_ram_147__3 B1=nx36192
Xcamera_module_cache_reg_ram_131__3 dffr $PINS Q=camera_module_cache_ram_131__3
+ QB=#dummy[1366] D=nx10963 CLK=clk R=rst
Xix10964 mux21_ni $PINS Y=nx10963 A0=camera_module_cache_ram_131__3 A1=nx35308
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__3 dffr $PINS Q=camera_module_cache_ram_147__3
+ QB=#dummy[1367] D=nx10953 CLK=clk R=rst
Xix10954 mux21_ni $PINS Y=nx10953 A0=camera_module_cache_ram_147__3 A1=nx35308
+ S0=nx34888
Xix30256 aoi22 $PINS Y=nx30255 A0=camera_module_cache_ram_179__3 A1=nx36232
+ B0=camera_module_cache_ram_163__3 B1=nx36272
Xcamera_module_cache_reg_ram_179__3 dffr $PINS Q=camera_module_cache_ram_179__3
+ QB=#dummy[1368] D=nx10933 CLK=clk R=rst
Xix10934 mux21_ni $PINS Y=nx10933 A0=camera_module_cache_ram_179__3 A1=nx35308
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__3 dffr $PINS Q=camera_module_cache_ram_163__3
+ QB=#dummy[1369] D=nx10943 CLK=clk R=rst
Xix10944 mux21_ni $PINS Y=nx10943 A0=camera_module_cache_ram_163__3 A1=nx35308
+ S0=nx34884
Xix30264 aoi22 $PINS Y=nx30263 A0=camera_module_cache_ram_195__3 A1=nx36312
+ B0=camera_module_cache_ram_211__3 B1=nx36352
Xcamera_module_cache_reg_ram_195__3 dffr $PINS Q=camera_module_cache_ram_195__3
+ QB=#dummy[1370] D=nx10923 CLK=clk R=rst
Xix10924 mux21_ni $PINS Y=nx10923 A0=camera_module_cache_ram_195__3 A1=nx35308
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__3 dffr $PINS Q=camera_module_cache_ram_211__3
+ QB=#dummy[1371] D=nx10913 CLK=clk R=rst
Xix10914 mux21_ni $PINS Y=nx10913 A0=camera_module_cache_ram_211__3 A1=nx35308
+ S0=nx34872
Xix30272 aoi22 $PINS Y=nx30271 A0=camera_module_cache_ram_227__3 A1=nx36392
+ B0=camera_module_cache_ram_243__3 B1=nx36432
Xcamera_module_cache_reg_ram_227__3 dffr $PINS Q=camera_module_cache_ram_227__3
+ QB=#dummy[1372] D=nx10903 CLK=clk R=rst
Xix10904 mux21_ni $PINS Y=nx10903 A0=camera_module_cache_ram_227__3 A1=nx35308
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__3 dffr $PINS Q=camera_module_cache_ram_243__3
+ QB=#dummy[1373] D=nx10893 CLK=clk R=rst
Xix10894 mux21_ni $PINS Y=nx10893 A0=camera_module_cache_ram_243__3 A1=nx35310
+ S0=nx34864
Xix13613 nand04 $PINS Y=nx13612 A0=nx30280 A1=nx30348 A2=nx30416 A3=nx30484
Xix30281 oai21 $PINS Y=nx30280 A0=nx13602 A1=nx13524 B0=nx36464
Xix13603 nand04 $PINS Y=nx13602 A0=nx30283 A1=nx30291 A2=nx30299 A3=nx30307
Xix30284 aoi22 $PINS Y=nx30283 A0=camera_module_cache_ram_4__3 A1=nx35832
+ B0=camera_module_cache_ram_20__3 B1=nx35872
Xcamera_module_cache_reg_ram_4__3 dffr $PINS Q=camera_module_cache_ram_4__3
+ QB=#dummy[1374] D=nx10883 CLK=clk R=rst
Xix10884 mux21_ni $PINS Y=nx10883 A0=camera_module_cache_ram_4__3 A1=nx35310
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__3 dffr $PINS Q=camera_module_cache_ram_20__3
+ QB=#dummy[1375] D=nx10873 CLK=clk R=rst
Xix10874 mux21_ni $PINS Y=nx10873 A0=camera_module_cache_ram_20__3 A1=nx35310
+ S0=nx34850
Xix30292 aoi22 $PINS Y=nx30291 A0=camera_module_cache_ram_36__3 A1=nx35912
+ B0=camera_module_cache_ram_52__3 B1=nx35952
Xcamera_module_cache_reg_ram_36__3 dffr $PINS Q=camera_module_cache_ram_36__3
+ QB=#dummy[1376] D=nx10863 CLK=clk R=rst
Xix10864 mux21_ni $PINS Y=nx10863 A0=camera_module_cache_ram_36__3 A1=nx35310
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__3 dffr $PINS Q=camera_module_cache_ram_52__3
+ QB=#dummy[1377] D=nx10853 CLK=clk R=rst
Xix10854 mux21_ni $PINS Y=nx10853 A0=camera_module_cache_ram_52__3 A1=nx35310
+ S0=nx34842
Xix30300 aoi22 $PINS Y=nx30299 A0=camera_module_cache_ram_68__3 A1=nx35992
+ B0=camera_module_cache_ram_84__3 B1=nx36032
Xcamera_module_cache_reg_ram_68__3 dffr $PINS Q=camera_module_cache_ram_68__3
+ QB=#dummy[1378] D=nx10843 CLK=clk R=rst
Xix10844 mux21_ni $PINS Y=nx10843 A0=camera_module_cache_ram_68__3 A1=nx35310
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__3 dffr $PINS Q=camera_module_cache_ram_84__3
+ QB=#dummy[1379] D=nx10833 CLK=clk R=rst
Xix10834 mux21_ni $PINS Y=nx10833 A0=camera_module_cache_ram_84__3 A1=nx35310
+ S0=nx34834
Xix30308 aoi22 $PINS Y=nx30307 A0=camera_module_cache_ram_116__3 A1=nx36072
+ B0=camera_module_cache_ram_100__3 B1=nx36112
Xcamera_module_cache_reg_ram_116__3 dffr $PINS Q=camera_module_cache_ram_116__3
+ QB=#dummy[1380] D=nx10813 CLK=clk R=rst
Xix10814 mux21_ni $PINS Y=nx10813 A0=camera_module_cache_ram_116__3 A1=nx35312
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__3 dffr $PINS Q=camera_module_cache_ram_100__3
+ QB=#dummy[1381] D=nx10823 CLK=clk R=rst
Xix10824 mux21_ni $PINS Y=nx10823 A0=camera_module_cache_ram_100__3 A1=nx35312
+ S0=nx34830
Xix13525 nand04 $PINS Y=nx13524 A0=nx30316 A1=nx30324 A2=nx30332 A3=nx30340
Xix30317 aoi22 $PINS Y=nx30316 A0=camera_module_cache_ram_132__3 A1=nx36152
+ B0=camera_module_cache_ram_148__3 B1=nx36192
Xcamera_module_cache_reg_ram_132__3 dffr $PINS Q=camera_module_cache_ram_132__3
+ QB=#dummy[1382] D=nx10803 CLK=clk R=rst
Xix10804 mux21_ni $PINS Y=nx10803 A0=camera_module_cache_ram_132__3 A1=nx35312
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__3 dffr $PINS Q=camera_module_cache_ram_148__3
+ QB=#dummy[1383] D=nx10793 CLK=clk R=rst
Xix10794 mux21_ni $PINS Y=nx10793 A0=camera_module_cache_ram_148__3 A1=nx35312
+ S0=nx34818
Xix30325 aoi22 $PINS Y=nx30324 A0=camera_module_cache_ram_180__3 A1=nx36232
+ B0=camera_module_cache_ram_164__3 B1=nx36272
Xcamera_module_cache_reg_ram_180__3 dffr $PINS Q=camera_module_cache_ram_180__3
+ QB=#dummy[1384] D=nx10773 CLK=clk R=rst
Xix10774 mux21_ni $PINS Y=nx10773 A0=camera_module_cache_ram_180__3 A1=nx35312
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__3 dffr $PINS Q=camera_module_cache_ram_164__3
+ QB=#dummy[1385] D=nx10783 CLK=clk R=rst
Xix10784 mux21_ni $PINS Y=nx10783 A0=camera_module_cache_ram_164__3 A1=nx35312
+ S0=nx34814
Xix30333 aoi22 $PINS Y=nx30332 A0=camera_module_cache_ram_196__3 A1=nx36312
+ B0=camera_module_cache_ram_212__3 B1=nx36352
Xcamera_module_cache_reg_ram_196__3 dffr $PINS Q=camera_module_cache_ram_196__3
+ QB=#dummy[1386] D=nx10763 CLK=clk R=rst
Xix10764 mux21_ni $PINS Y=nx10763 A0=camera_module_cache_ram_196__3 A1=nx35312
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__3 dffr $PINS Q=camera_module_cache_ram_212__3
+ QB=#dummy[1387] D=nx10753 CLK=clk R=rst
Xix10754 mux21_ni $PINS Y=nx10753 A0=camera_module_cache_ram_212__3 A1=nx35314
+ S0=nx34802
Xix30341 aoi22 $PINS Y=nx30340 A0=camera_module_cache_ram_228__3 A1=nx36392
+ B0=camera_module_cache_ram_244__3 B1=nx36432
Xcamera_module_cache_reg_ram_228__3 dffr $PINS Q=camera_module_cache_ram_228__3
+ QB=#dummy[1388] D=nx10743 CLK=clk R=rst
Xix10744 mux21_ni $PINS Y=nx10743 A0=camera_module_cache_ram_228__3 A1=nx35314
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__3 dffr $PINS Q=camera_module_cache_ram_244__3
+ QB=#dummy[1389] D=nx10733 CLK=clk R=rst
Xix10734 mux21_ni $PINS Y=nx10733 A0=camera_module_cache_ram_244__3 A1=nx35314
+ S0=nx34794
Xix30349 oai21 $PINS Y=nx30348 A0=nx13440 A1=nx13362 B0=nx36468
Xix13441 nand04 $PINS Y=nx13440 A0=nx30351 A1=nx30359 A2=nx30367 A3=nx30375
Xix30352 aoi22 $PINS Y=nx30351 A0=camera_module_cache_ram_5__3 A1=nx35832
+ B0=camera_module_cache_ram_21__3 B1=nx35872
Xcamera_module_cache_reg_ram_5__3 dffr $PINS Q=camera_module_cache_ram_5__3
+ QB=#dummy[1390] D=nx10723 CLK=clk R=rst
Xix10724 mux21_ni $PINS Y=nx10723 A0=camera_module_cache_ram_5__3 A1=nx35314
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__3 dffr $PINS Q=camera_module_cache_ram_21__3
+ QB=#dummy[1391] D=nx10713 CLK=clk R=rst
Xix10714 mux21_ni $PINS Y=nx10713 A0=camera_module_cache_ram_21__3 A1=nx35314
+ S0=nx34780
Xix30360 aoi22 $PINS Y=nx30359 A0=camera_module_cache_ram_37__3 A1=nx35912
+ B0=camera_module_cache_ram_53__3 B1=nx35952
Xcamera_module_cache_reg_ram_37__3 dffr $PINS Q=camera_module_cache_ram_37__3
+ QB=#dummy[1392] D=nx10703 CLK=clk R=rst
Xix10704 mux21_ni $PINS Y=nx10703 A0=camera_module_cache_ram_37__3 A1=nx35314
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__3 dffr $PINS Q=camera_module_cache_ram_53__3
+ QB=#dummy[1393] D=nx10693 CLK=clk R=rst
Xix10694 mux21_ni $PINS Y=nx10693 A0=camera_module_cache_ram_53__3 A1=nx35314
+ S0=nx34772
Xix30368 aoi22 $PINS Y=nx30367 A0=camera_module_cache_ram_69__3 A1=nx35992
+ B0=camera_module_cache_ram_85__3 B1=nx36032
Xcamera_module_cache_reg_ram_69__3 dffr $PINS Q=camera_module_cache_ram_69__3
+ QB=#dummy[1394] D=nx10683 CLK=clk R=rst
Xix10684 mux21_ni $PINS Y=nx10683 A0=camera_module_cache_ram_69__3 A1=nx35316
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__3 dffr $PINS Q=camera_module_cache_ram_85__3
+ QB=#dummy[1395] D=nx10673 CLK=clk R=rst
Xix10674 mux21_ni $PINS Y=nx10673 A0=camera_module_cache_ram_85__3 A1=nx35316
+ S0=nx34764
Xix30376 aoi22 $PINS Y=nx30375 A0=camera_module_cache_ram_117__3 A1=nx36072
+ B0=camera_module_cache_ram_101__3 B1=nx36112
Xcamera_module_cache_reg_ram_117__3 dffr $PINS Q=camera_module_cache_ram_117__3
+ QB=#dummy[1396] D=nx10653 CLK=clk R=rst
Xix10654 mux21_ni $PINS Y=nx10653 A0=camera_module_cache_ram_117__3 A1=nx35316
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__3 dffr $PINS Q=camera_module_cache_ram_101__3
+ QB=#dummy[1397] D=nx10663 CLK=clk R=rst
Xix10664 mux21_ni $PINS Y=nx10663 A0=camera_module_cache_ram_101__3 A1=nx35316
+ S0=nx34760
Xix13363 nand04 $PINS Y=nx13362 A0=nx30384 A1=nx30392 A2=nx30400 A3=nx30408
Xix30385 aoi22 $PINS Y=nx30384 A0=camera_module_cache_ram_133__3 A1=nx36152
+ B0=camera_module_cache_ram_149__3 B1=nx36192
Xcamera_module_cache_reg_ram_133__3 dffr $PINS Q=camera_module_cache_ram_133__3
+ QB=#dummy[1398] D=nx10643 CLK=clk R=rst
Xix10644 mux21_ni $PINS Y=nx10643 A0=camera_module_cache_ram_133__3 A1=nx35316
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__3 dffr $PINS Q=camera_module_cache_ram_149__3
+ QB=#dummy[1399] D=nx10633 CLK=clk R=rst
Xix10634 mux21_ni $PINS Y=nx10633 A0=camera_module_cache_ram_149__3 A1=nx35316
+ S0=nx34748
Xix30393 aoi22 $PINS Y=nx30392 A0=camera_module_cache_ram_181__3 A1=nx36232
+ B0=camera_module_cache_ram_165__3 B1=nx36272
Xcamera_module_cache_reg_ram_181__3 dffr $PINS Q=camera_module_cache_ram_181__3
+ QB=#dummy[1400] D=nx10613 CLK=clk R=rst
Xix10614 mux21_ni $PINS Y=nx10613 A0=camera_module_cache_ram_181__3 A1=nx35316
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__3 dffr $PINS Q=camera_module_cache_ram_165__3
+ QB=#dummy[1401] D=nx10623 CLK=clk R=rst
Xix10624 mux21_ni $PINS Y=nx10623 A0=camera_module_cache_ram_165__3 A1=nx35318
+ S0=nx34744
Xix30401 aoi22 $PINS Y=nx30400 A0=camera_module_cache_ram_197__3 A1=nx36312
+ B0=camera_module_cache_ram_213__3 B1=nx36352
Xcamera_module_cache_reg_ram_197__3 dffr $PINS Q=camera_module_cache_ram_197__3
+ QB=#dummy[1402] D=nx10603 CLK=clk R=rst
Xix10604 mux21_ni $PINS Y=nx10603 A0=camera_module_cache_ram_197__3 A1=nx35318
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__3 dffr $PINS Q=camera_module_cache_ram_213__3
+ QB=#dummy[1403] D=nx10593 CLK=clk R=rst
Xix10594 mux21_ni $PINS Y=nx10593 A0=camera_module_cache_ram_213__3 A1=nx35318
+ S0=nx34732
Xix30409 aoi22 $PINS Y=nx30408 A0=camera_module_cache_ram_229__3 A1=nx36392
+ B0=camera_module_cache_ram_245__3 B1=nx36432
Xcamera_module_cache_reg_ram_229__3 dffr $PINS Q=camera_module_cache_ram_229__3
+ QB=#dummy[1404] D=nx10583 CLK=clk R=rst
Xix10584 mux21_ni $PINS Y=nx10583 A0=camera_module_cache_ram_229__3 A1=nx35318
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__3 dffr $PINS Q=camera_module_cache_ram_245__3
+ QB=#dummy[1405] D=nx10573 CLK=clk R=rst
Xix10574 mux21_ni $PINS Y=nx10573 A0=camera_module_cache_ram_245__3 A1=nx35318
+ S0=nx34724
Xix30417 oai21 $PINS Y=nx30416 A0=nx13276 A1=nx13198 B0=nx36472
Xix13277 nand04 $PINS Y=nx13276 A0=nx30419 A1=nx30427 A2=nx30435 A3=nx30443
Xix30420 aoi22 $PINS Y=nx30419 A0=camera_module_cache_ram_6__3 A1=nx35832
+ B0=camera_module_cache_ram_22__3 B1=nx35872
Xcamera_module_cache_reg_ram_6__3 dffr $PINS Q=camera_module_cache_ram_6__3
+ QB=#dummy[1406] D=nx10563 CLK=clk R=rst
Xix10564 mux21_ni $PINS Y=nx10563 A0=camera_module_cache_ram_6__3 A1=nx35318
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__3 dffr $PINS Q=camera_module_cache_ram_22__3
+ QB=#dummy[1407] D=nx10553 CLK=clk R=rst
Xix10554 mux21_ni $PINS Y=nx10553 A0=camera_module_cache_ram_22__3 A1=nx35318
+ S0=nx34710
Xix30428 aoi22 $PINS Y=nx30427 A0=camera_module_cache_ram_38__3 A1=nx35912
+ B0=camera_module_cache_ram_54__3 B1=nx35952
Xcamera_module_cache_reg_ram_38__3 dffr $PINS Q=camera_module_cache_ram_38__3
+ QB=#dummy[1408] D=nx10543 CLK=clk R=rst
Xix10544 mux21_ni $PINS Y=nx10543 A0=camera_module_cache_ram_38__3 A1=nx35320
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__3 dffr $PINS Q=camera_module_cache_ram_54__3
+ QB=#dummy[1409] D=nx10533 CLK=clk R=rst
Xix10534 mux21_ni $PINS Y=nx10533 A0=camera_module_cache_ram_54__3 A1=nx35320
+ S0=nx34702
Xix30436 aoi22 $PINS Y=nx30435 A0=camera_module_cache_ram_70__3 A1=nx35992
+ B0=camera_module_cache_ram_86__3 B1=nx36032
Xcamera_module_cache_reg_ram_70__3 dffr $PINS Q=camera_module_cache_ram_70__3
+ QB=#dummy[1410] D=nx10523 CLK=clk R=rst
Xix10524 mux21_ni $PINS Y=nx10523 A0=camera_module_cache_ram_70__3 A1=nx35320
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__3 dffr $PINS Q=camera_module_cache_ram_86__3
+ QB=#dummy[1411] D=nx10513 CLK=clk R=rst
Xix10514 mux21_ni $PINS Y=nx10513 A0=camera_module_cache_ram_86__3 A1=nx35320
+ S0=nx34694
Xix30444 aoi22 $PINS Y=nx30443 A0=camera_module_cache_ram_118__3 A1=nx36072
+ B0=camera_module_cache_ram_102__3 B1=nx36112
Xcamera_module_cache_reg_ram_118__3 dffr $PINS Q=camera_module_cache_ram_118__3
+ QB=#dummy[1412] D=nx10493 CLK=clk R=rst
Xix10494 mux21_ni $PINS Y=nx10493 A0=camera_module_cache_ram_118__3 A1=nx35320
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__3 dffr $PINS Q=camera_module_cache_ram_102__3
+ QB=#dummy[1413] D=nx10503 CLK=clk R=rst
Xix10504 mux21_ni $PINS Y=nx10503 A0=camera_module_cache_ram_102__3 A1=nx35320
+ S0=nx34690
Xix13199 nand04 $PINS Y=nx13198 A0=nx30452 A1=nx30460 A2=nx30468 A3=nx30476
Xix30453 aoi22 $PINS Y=nx30452 A0=camera_module_cache_ram_134__3 A1=nx36152
+ B0=camera_module_cache_ram_150__3 B1=nx36192
Xcamera_module_cache_reg_ram_134__3 dffr $PINS Q=camera_module_cache_ram_134__3
+ QB=#dummy[1414] D=nx10483 CLK=clk R=rst
Xix10484 mux21_ni $PINS Y=nx10483 A0=camera_module_cache_ram_134__3 A1=nx35320
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__3 dffr $PINS Q=camera_module_cache_ram_150__3
+ QB=#dummy[1415] D=nx10473 CLK=clk R=rst
Xix10474 mux21_ni $PINS Y=nx10473 A0=camera_module_cache_ram_150__3 A1=nx35322
+ S0=nx34678
Xix30461 aoi22 $PINS Y=nx30460 A0=camera_module_cache_ram_182__3 A1=nx36232
+ B0=camera_module_cache_ram_166__3 B1=nx36272
Xcamera_module_cache_reg_ram_182__3 dffr $PINS Q=camera_module_cache_ram_182__3
+ QB=#dummy[1416] D=nx10453 CLK=clk R=rst
Xix10454 mux21_ni $PINS Y=nx10453 A0=camera_module_cache_ram_182__3 A1=nx35322
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__3 dffr $PINS Q=camera_module_cache_ram_166__3
+ QB=#dummy[1417] D=nx10463 CLK=clk R=rst
Xix10464 mux21_ni $PINS Y=nx10463 A0=camera_module_cache_ram_166__3 A1=nx35322
+ S0=nx34674
Xix30469 aoi22 $PINS Y=nx30468 A0=camera_module_cache_ram_198__3 A1=nx36312
+ B0=camera_module_cache_ram_214__3 B1=nx36352
Xcamera_module_cache_reg_ram_198__3 dffr $PINS Q=camera_module_cache_ram_198__3
+ QB=#dummy[1418] D=nx10443 CLK=clk R=rst
Xix10444 mux21_ni $PINS Y=nx10443 A0=camera_module_cache_ram_198__3 A1=nx35322
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__3 dffr $PINS Q=camera_module_cache_ram_214__3
+ QB=#dummy[1419] D=nx10433 CLK=clk R=rst
Xix10434 mux21_ni $PINS Y=nx10433 A0=camera_module_cache_ram_214__3 A1=nx35322
+ S0=nx34662
Xix30477 aoi22 $PINS Y=nx30476 A0=camera_module_cache_ram_230__3 A1=nx36392
+ B0=camera_module_cache_ram_246__3 B1=nx36432
Xcamera_module_cache_reg_ram_230__3 dffr $PINS Q=camera_module_cache_ram_230__3
+ QB=#dummy[1420] D=nx10423 CLK=clk R=rst
Xix10424 mux21_ni $PINS Y=nx10423 A0=camera_module_cache_ram_230__3 A1=nx35322
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__3 dffr $PINS Q=camera_module_cache_ram_246__3
+ QB=#dummy[1421] D=nx10413 CLK=clk R=rst
Xix10414 mux21_ni $PINS Y=nx10413 A0=camera_module_cache_ram_246__3 A1=nx35322
+ S0=nx34654
Xix30485 oai21 $PINS Y=nx30484 A0=nx13114 A1=nx13036 B0=nx36476
Xix13115 nand04 $PINS Y=nx13114 A0=nx30487 A1=nx30495 A2=nx30503 A3=nx30511
Xix30488 aoi22 $PINS Y=nx30487 A0=camera_module_cache_ram_7__3 A1=nx35834
+ B0=camera_module_cache_ram_23__3 B1=nx35874
Xcamera_module_cache_reg_ram_7__3 dffr $PINS Q=camera_module_cache_ram_7__3
+ QB=#dummy[1422] D=nx10403 CLK=clk R=rst
Xix10404 mux21_ni $PINS Y=nx10403 A0=camera_module_cache_ram_7__3 A1=nx35324
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__3 dffr $PINS Q=camera_module_cache_ram_23__3
+ QB=#dummy[1423] D=nx10393 CLK=clk R=rst
Xix10394 mux21_ni $PINS Y=nx10393 A0=camera_module_cache_ram_23__3 A1=nx35324
+ S0=nx34640
Xix30496 aoi22 $PINS Y=nx30495 A0=camera_module_cache_ram_39__3 A1=nx35914
+ B0=camera_module_cache_ram_55__3 B1=nx35954
Xcamera_module_cache_reg_ram_39__3 dffr $PINS Q=camera_module_cache_ram_39__3
+ QB=#dummy[1424] D=nx10383 CLK=clk R=rst
Xix10384 mux21_ni $PINS Y=nx10383 A0=camera_module_cache_ram_39__3 A1=nx35324
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__3 dffr $PINS Q=camera_module_cache_ram_55__3
+ QB=#dummy[1425] D=nx10373 CLK=clk R=rst
Xix10374 mux21_ni $PINS Y=nx10373 A0=camera_module_cache_ram_55__3 A1=nx35324
+ S0=nx34632
Xix30504 aoi22 $PINS Y=nx30503 A0=camera_module_cache_ram_71__3 A1=nx35994
+ B0=camera_module_cache_ram_87__3 B1=nx36034
Xcamera_module_cache_reg_ram_71__3 dffr $PINS Q=camera_module_cache_ram_71__3
+ QB=#dummy[1426] D=nx10363 CLK=clk R=rst
Xix10364 mux21_ni $PINS Y=nx10363 A0=camera_module_cache_ram_71__3 A1=nx35324
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__3 dffr $PINS Q=camera_module_cache_ram_87__3
+ QB=#dummy[1427] D=nx10353 CLK=clk R=rst
Xix10354 mux21_ni $PINS Y=nx10353 A0=camera_module_cache_ram_87__3 A1=nx35324
+ S0=nx34624
Xix30512 aoi22 $PINS Y=nx30511 A0=camera_module_cache_ram_119__3 A1=nx36074
+ B0=camera_module_cache_ram_103__3 B1=nx36114
Xcamera_module_cache_reg_ram_119__3 dffr $PINS Q=camera_module_cache_ram_119__3
+ QB=#dummy[1428] D=nx10333 CLK=clk R=rst
Xix10334 mux21_ni $PINS Y=nx10333 A0=camera_module_cache_ram_119__3 A1=nx35324
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__3 dffr $PINS Q=camera_module_cache_ram_103__3
+ QB=#dummy[1429] D=nx10343 CLK=clk R=rst
Xix10344 mux21_ni $PINS Y=nx10343 A0=camera_module_cache_ram_103__3 A1=nx35326
+ S0=nx34620
Xix13037 nand04 $PINS Y=nx13036 A0=nx30520 A1=nx30528 A2=nx30536 A3=nx30544
Xix30521 aoi22 $PINS Y=nx30520 A0=camera_module_cache_ram_135__3 A1=nx36154
+ B0=camera_module_cache_ram_151__3 B1=nx36194
Xcamera_module_cache_reg_ram_135__3 dffr $PINS Q=camera_module_cache_ram_135__3
+ QB=#dummy[1430] D=nx10323 CLK=clk R=rst
Xix10324 mux21_ni $PINS Y=nx10323 A0=camera_module_cache_ram_135__3 A1=nx35326
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__3 dffr $PINS Q=camera_module_cache_ram_151__3
+ QB=#dummy[1431] D=nx10313 CLK=clk R=rst
Xix10314 mux21_ni $PINS Y=nx10313 A0=camera_module_cache_ram_151__3 A1=nx35326
+ S0=nx34608
Xix30529 aoi22 $PINS Y=nx30528 A0=camera_module_cache_ram_183__3 A1=nx36234
+ B0=camera_module_cache_ram_167__3 B1=nx36274
Xcamera_module_cache_reg_ram_183__3 dffr $PINS Q=camera_module_cache_ram_183__3
+ QB=#dummy[1432] D=nx10293 CLK=clk R=rst
Xix10294 mux21_ni $PINS Y=nx10293 A0=camera_module_cache_ram_183__3 A1=nx35326
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__3 dffr $PINS Q=camera_module_cache_ram_167__3
+ QB=#dummy[1433] D=nx10303 CLK=clk R=rst
Xix10304 mux21_ni $PINS Y=nx10303 A0=camera_module_cache_ram_167__3 A1=nx35326
+ S0=nx34604
Xix30537 aoi22 $PINS Y=nx30536 A0=camera_module_cache_ram_199__3 A1=nx36314
+ B0=camera_module_cache_ram_215__3 B1=nx36354
Xcamera_module_cache_reg_ram_199__3 dffr $PINS Q=camera_module_cache_ram_199__3
+ QB=#dummy[1434] D=nx10283 CLK=clk R=rst
Xix10284 mux21_ni $PINS Y=nx10283 A0=camera_module_cache_ram_199__3 A1=nx35326
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__3 dffr $PINS Q=camera_module_cache_ram_215__3
+ QB=#dummy[1435] D=nx10273 CLK=clk R=rst
Xix10274 mux21_ni $PINS Y=nx10273 A0=camera_module_cache_ram_215__3 A1=nx35326
+ S0=nx34592
Xix30545 aoi22 $PINS Y=nx30544 A0=camera_module_cache_ram_231__3 A1=nx36394
+ B0=camera_module_cache_ram_247__3 B1=nx36434
Xcamera_module_cache_reg_ram_231__3 dffr $PINS Q=camera_module_cache_ram_231__3
+ QB=#dummy[1436] D=nx10263 CLK=clk R=rst
Xix10264 mux21_ni $PINS Y=nx10263 A0=camera_module_cache_ram_231__3 A1=nx35328
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__3 dffr $PINS Q=camera_module_cache_ram_247__3
+ QB=#dummy[1437] D=nx10253 CLK=clk R=rst
Xix10254 mux21_ni $PINS Y=nx10253 A0=camera_module_cache_ram_247__3 A1=nx35328
+ S0=nx34584
Xix12957 nand04 $PINS Y=nx12956 A0=nx30553 A1=nx30621 A2=nx30689 A3=nx30757
Xix30554 oai21 $PINS Y=nx30553 A0=nx12946 A1=nx12868 B0=nx36480
Xix12947 nand04 $PINS Y=nx12946 A0=nx30556 A1=nx30564 A2=nx30572 A3=nx30580
Xix30557 aoi22 $PINS Y=nx30556 A0=camera_module_cache_ram_8__3 A1=nx35834
+ B0=camera_module_cache_ram_24__3 B1=nx35874
Xcamera_module_cache_reg_ram_8__3 dffr $PINS Q=camera_module_cache_ram_8__3
+ QB=#dummy[1438] D=nx10243 CLK=clk R=rst
Xix10244 mux21_ni $PINS Y=nx10243 A0=camera_module_cache_ram_8__3 A1=nx35328
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__3 dffr $PINS Q=camera_module_cache_ram_24__3
+ QB=#dummy[1439] D=nx10233 CLK=clk R=rst
Xix10234 mux21_ni $PINS Y=nx10233 A0=camera_module_cache_ram_24__3 A1=nx35328
+ S0=nx34570
Xix30565 aoi22 $PINS Y=nx30564 A0=camera_module_cache_ram_40__3 A1=nx35914
+ B0=camera_module_cache_ram_56__3 B1=nx35954
Xcamera_module_cache_reg_ram_40__3 dffr $PINS Q=camera_module_cache_ram_40__3
+ QB=#dummy[1440] D=nx10223 CLK=clk R=rst
Xix10224 mux21_ni $PINS Y=nx10223 A0=camera_module_cache_ram_40__3 A1=nx35328
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__3 dffr $PINS Q=camera_module_cache_ram_56__3
+ QB=#dummy[1441] D=nx10213 CLK=clk R=rst
Xix10214 mux21_ni $PINS Y=nx10213 A0=camera_module_cache_ram_56__3 A1=nx35328
+ S0=nx34562
Xix30573 aoi22 $PINS Y=nx30572 A0=camera_module_cache_ram_72__3 A1=nx35994
+ B0=camera_module_cache_ram_88__3 B1=nx36034
Xcamera_module_cache_reg_ram_72__3 dffr $PINS Q=camera_module_cache_ram_72__3
+ QB=#dummy[1442] D=nx10203 CLK=clk R=rst
Xix10204 mux21_ni $PINS Y=nx10203 A0=camera_module_cache_ram_72__3 A1=nx35328
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__3 dffr $PINS Q=camera_module_cache_ram_88__3
+ QB=#dummy[1443] D=nx10193 CLK=clk R=rst
Xix10194 mux21_ni $PINS Y=nx10193 A0=camera_module_cache_ram_88__3 A1=nx35330
+ S0=nx34554
Xix30581 aoi22 $PINS Y=nx30580 A0=camera_module_cache_ram_120__3 A1=nx36074
+ B0=camera_module_cache_ram_104__3 B1=nx36114
Xcamera_module_cache_reg_ram_120__3 dffr $PINS Q=camera_module_cache_ram_120__3
+ QB=#dummy[1444] D=nx10173 CLK=clk R=rst
Xix10174 mux21_ni $PINS Y=nx10173 A0=camera_module_cache_ram_120__3 A1=nx35330
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__3 dffr $PINS Q=camera_module_cache_ram_104__3
+ QB=#dummy[1445] D=nx10183 CLK=clk R=rst
Xix10184 mux21_ni $PINS Y=nx10183 A0=camera_module_cache_ram_104__3 A1=nx35330
+ S0=nx34550
Xix12869 nand04 $PINS Y=nx12868 A0=nx30589 A1=nx30597 A2=nx30605 A3=nx30613
Xix30590 aoi22 $PINS Y=nx30589 A0=camera_module_cache_ram_136__3 A1=nx36154
+ B0=camera_module_cache_ram_152__3 B1=nx36194
Xcamera_module_cache_reg_ram_136__3 dffr $PINS Q=camera_module_cache_ram_136__3
+ QB=#dummy[1446] D=nx10163 CLK=clk R=rst
Xix10164 mux21_ni $PINS Y=nx10163 A0=camera_module_cache_ram_136__3 A1=nx35330
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__3 dffr $PINS Q=camera_module_cache_ram_152__3
+ QB=#dummy[1447] D=nx10153 CLK=clk R=rst
Xix10154 mux21_ni $PINS Y=nx10153 A0=camera_module_cache_ram_152__3 A1=nx35330
+ S0=nx34538
Xix30598 aoi22 $PINS Y=nx30597 A0=camera_module_cache_ram_184__3 A1=nx36234
+ B0=camera_module_cache_ram_168__3 B1=nx36274
Xcamera_module_cache_reg_ram_184__3 dffr $PINS Q=camera_module_cache_ram_184__3
+ QB=#dummy[1448] D=nx10133 CLK=clk R=rst
Xix10134 mux21_ni $PINS Y=nx10133 A0=camera_module_cache_ram_184__3 A1=nx35330
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__3 dffr $PINS Q=camera_module_cache_ram_168__3
+ QB=#dummy[1449] D=nx10143 CLK=clk R=rst
Xix10144 mux21_ni $PINS Y=nx10143 A0=camera_module_cache_ram_168__3 A1=nx35330
+ S0=nx34534
Xix30606 aoi22 $PINS Y=nx30605 A0=camera_module_cache_ram_200__3 A1=nx36314
+ B0=camera_module_cache_ram_216__3 B1=nx36354
Xcamera_module_cache_reg_ram_200__3 dffr $PINS Q=camera_module_cache_ram_200__3
+ QB=#dummy[1450] D=nx10123 CLK=clk R=rst
Xix10124 mux21_ni $PINS Y=nx10123 A0=camera_module_cache_ram_200__3 A1=nx35332
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__3 dffr $PINS Q=camera_module_cache_ram_216__3
+ QB=#dummy[1451] D=nx10113 CLK=clk R=rst
Xix10114 mux21_ni $PINS Y=nx10113 A0=camera_module_cache_ram_216__3 A1=nx35332
+ S0=nx34522
Xix30614 aoi22 $PINS Y=nx30613 A0=camera_module_cache_ram_232__3 A1=nx36394
+ B0=camera_module_cache_ram_248__3 B1=nx36434
Xcamera_module_cache_reg_ram_232__3 dffr $PINS Q=camera_module_cache_ram_232__3
+ QB=#dummy[1452] D=nx10103 CLK=clk R=rst
Xix10104 mux21_ni $PINS Y=nx10103 A0=camera_module_cache_ram_232__3 A1=nx35332
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__3 dffr $PINS Q=camera_module_cache_ram_248__3
+ QB=#dummy[1453] D=nx10093 CLK=clk R=rst
Xix10094 mux21_ni $PINS Y=nx10093 A0=camera_module_cache_ram_248__3 A1=nx35332
+ S0=nx34514
Xix30622 oai21 $PINS Y=nx30621 A0=nx12784 A1=nx12706 B0=nx36484
Xix12785 nand04 $PINS Y=nx12784 A0=nx30624 A1=nx30632 A2=nx30640 A3=nx30648
Xix30625 aoi22 $PINS Y=nx30624 A0=camera_module_cache_ram_9__3 A1=nx35834
+ B0=camera_module_cache_ram_25__3 B1=nx35874
Xcamera_module_cache_reg_ram_9__3 dffr $PINS Q=camera_module_cache_ram_9__3
+ QB=#dummy[1454] D=nx10083 CLK=clk R=rst
Xix10084 mux21_ni $PINS Y=nx10083 A0=camera_module_cache_ram_9__3 A1=nx35332
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__3 dffr $PINS Q=camera_module_cache_ram_25__3
+ QB=#dummy[1455] D=nx10073 CLK=clk R=rst
Xix10074 mux21_ni $PINS Y=nx10073 A0=camera_module_cache_ram_25__3 A1=nx35332
+ S0=nx34500
Xix30633 aoi22 $PINS Y=nx30632 A0=camera_module_cache_ram_41__3 A1=nx35914
+ B0=camera_module_cache_ram_57__3 B1=nx35954
Xcamera_module_cache_reg_ram_41__3 dffr $PINS Q=camera_module_cache_ram_41__3
+ QB=#dummy[1456] D=nx10063 CLK=clk R=rst
Xix10064 mux21_ni $PINS Y=nx10063 A0=camera_module_cache_ram_41__3 A1=nx35332
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__3 dffr $PINS Q=camera_module_cache_ram_57__3
+ QB=#dummy[1457] D=nx10053 CLK=clk R=rst
Xix10054 mux21_ni $PINS Y=nx10053 A0=camera_module_cache_ram_57__3 A1=nx35334
+ S0=nx34492
Xix30641 aoi22 $PINS Y=nx30640 A0=camera_module_cache_ram_73__3 A1=nx35994
+ B0=camera_module_cache_ram_89__3 B1=nx36034
Xcamera_module_cache_reg_ram_73__3 dffr $PINS Q=camera_module_cache_ram_73__3
+ QB=#dummy[1458] D=nx10043 CLK=clk R=rst
Xix10044 mux21_ni $PINS Y=nx10043 A0=camera_module_cache_ram_73__3 A1=nx35334
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__3 dffr $PINS Q=camera_module_cache_ram_89__3
+ QB=#dummy[1459] D=nx10033 CLK=clk R=rst
Xix10034 mux21_ni $PINS Y=nx10033 A0=camera_module_cache_ram_89__3 A1=nx35334
+ S0=nx34484
Xix30649 aoi22 $PINS Y=nx30648 A0=camera_module_cache_ram_121__3 A1=nx36074
+ B0=camera_module_cache_ram_105__3 B1=nx36114
Xcamera_module_cache_reg_ram_121__3 dffr $PINS Q=camera_module_cache_ram_121__3
+ QB=#dummy[1460] D=nx10013 CLK=clk R=rst
Xix10014 mux21_ni $PINS Y=nx10013 A0=camera_module_cache_ram_121__3 A1=nx35334
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__3 dffr $PINS Q=camera_module_cache_ram_105__3
+ QB=#dummy[1461] D=nx10023 CLK=clk R=rst
Xix10024 mux21_ni $PINS Y=nx10023 A0=camera_module_cache_ram_105__3 A1=nx35334
+ S0=nx34480
Xix12707 nand04 $PINS Y=nx12706 A0=nx30657 A1=nx30665 A2=nx30673 A3=nx30681
Xix30658 aoi22 $PINS Y=nx30657 A0=camera_module_cache_ram_137__3 A1=nx36154
+ B0=camera_module_cache_ram_153__3 B1=nx36194
Xcamera_module_cache_reg_ram_137__3 dffr $PINS Q=camera_module_cache_ram_137__3
+ QB=#dummy[1462] D=nx10003 CLK=clk R=rst
Xix10004 mux21_ni $PINS Y=nx10003 A0=camera_module_cache_ram_137__3 A1=nx35334
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__3 dffr $PINS Q=camera_module_cache_ram_153__3
+ QB=#dummy[1463] D=nx9993 CLK=clk R=rst
Xix9994 mux21_ni $PINS Y=nx9993 A0=camera_module_cache_ram_153__3 A1=nx35334
+ S0=nx34468
Xix30666 aoi22 $PINS Y=nx30665 A0=camera_module_cache_ram_185__3 A1=nx36234
+ B0=camera_module_cache_ram_169__3 B1=nx36274
Xcamera_module_cache_reg_ram_185__3 dffr $PINS Q=camera_module_cache_ram_185__3
+ QB=#dummy[1464] D=nx9973 CLK=clk R=rst
Xix9974 mux21_ni $PINS Y=nx9973 A0=camera_module_cache_ram_185__3 A1=nx35336
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__3 dffr $PINS Q=camera_module_cache_ram_169__3
+ QB=#dummy[1465] D=nx9983 CLK=clk R=rst
Xix9984 mux21_ni $PINS Y=nx9983 A0=camera_module_cache_ram_169__3 A1=nx35336
+ S0=nx34464
Xix30674 aoi22 $PINS Y=nx30673 A0=camera_module_cache_ram_201__3 A1=nx36314
+ B0=camera_module_cache_ram_217__3 B1=nx36354
Xcamera_module_cache_reg_ram_201__3 dffr $PINS Q=camera_module_cache_ram_201__3
+ QB=#dummy[1466] D=nx9963 CLK=clk R=rst
Xix9964 mux21_ni $PINS Y=nx9963 A0=camera_module_cache_ram_201__3 A1=nx35336
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__3 dffr $PINS Q=camera_module_cache_ram_217__3
+ QB=#dummy[1467] D=nx9953 CLK=clk R=rst
Xix9954 mux21_ni $PINS Y=nx9953 A0=camera_module_cache_ram_217__3 A1=nx35336
+ S0=nx34452
Xix30682 aoi22 $PINS Y=nx30681 A0=camera_module_cache_ram_233__3 A1=nx36394
+ B0=camera_module_cache_ram_249__3 B1=nx36434
Xcamera_module_cache_reg_ram_233__3 dffr $PINS Q=camera_module_cache_ram_233__3
+ QB=#dummy[1468] D=nx9943 CLK=clk R=rst
Xix9944 mux21_ni $PINS Y=nx9943 A0=camera_module_cache_ram_233__3 A1=nx35336
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__3 dffr $PINS Q=camera_module_cache_ram_249__3
+ QB=#dummy[1469] D=nx9933 CLK=clk R=rst
Xix9934 mux21_ni $PINS Y=nx9933 A0=camera_module_cache_ram_249__3 A1=nx35336
+ S0=nx34444
Xix30690 oai21 $PINS Y=nx30689 A0=nx12620 A1=nx12542 B0=nx36488
Xix12621 nand04 $PINS Y=nx12620 A0=nx30692 A1=nx30700 A2=nx30708 A3=nx30716
Xix30693 aoi22 $PINS Y=nx30692 A0=camera_module_cache_ram_10__3 A1=nx35834
+ B0=camera_module_cache_ram_26__3 B1=nx35874
Xcamera_module_cache_reg_ram_10__3 dffr $PINS Q=camera_module_cache_ram_10__3
+ QB=#dummy[1470] D=nx9923 CLK=clk R=rst
Xix9924 mux21_ni $PINS Y=nx9923 A0=camera_module_cache_ram_10__3 A1=nx35336
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__3 dffr $PINS Q=camera_module_cache_ram_26__3
+ QB=#dummy[1471] D=nx9913 CLK=clk R=rst
Xix9914 mux21_ni $PINS Y=nx9913 A0=camera_module_cache_ram_26__3 A1=nx35338
+ S0=nx34430
Xix30701 aoi22 $PINS Y=nx30700 A0=camera_module_cache_ram_42__3 A1=nx35914
+ B0=camera_module_cache_ram_58__3 B1=nx35954
Xcamera_module_cache_reg_ram_42__3 dffr $PINS Q=camera_module_cache_ram_42__3
+ QB=#dummy[1472] D=nx9903 CLK=clk R=rst
Xix9904 mux21_ni $PINS Y=nx9903 A0=camera_module_cache_ram_42__3 A1=nx35338
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__3 dffr $PINS Q=camera_module_cache_ram_58__3
+ QB=#dummy[1473] D=nx9893 CLK=clk R=rst
Xix9894 mux21_ni $PINS Y=nx9893 A0=camera_module_cache_ram_58__3 A1=nx35338
+ S0=nx34422
Xix30709 aoi22 $PINS Y=nx30708 A0=camera_module_cache_ram_74__3 A1=nx35994
+ B0=camera_module_cache_ram_90__3 B1=nx36034
Xcamera_module_cache_reg_ram_74__3 dffr $PINS Q=camera_module_cache_ram_74__3
+ QB=#dummy[1474] D=nx9883 CLK=clk R=rst
Xix9884 mux21_ni $PINS Y=nx9883 A0=camera_module_cache_ram_74__3 A1=nx35338
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__3 dffr $PINS Q=camera_module_cache_ram_90__3
+ QB=#dummy[1475] D=nx9873 CLK=clk R=rst
Xix9874 mux21_ni $PINS Y=nx9873 A0=camera_module_cache_ram_90__3 A1=nx35338
+ S0=nx34414
Xix30717 aoi22 $PINS Y=nx30716 A0=camera_module_cache_ram_122__3 A1=nx36074
+ B0=camera_module_cache_ram_106__3 B1=nx36114
Xcamera_module_cache_reg_ram_122__3 dffr $PINS Q=camera_module_cache_ram_122__3
+ QB=#dummy[1476] D=nx9853 CLK=clk R=rst
Xix9854 mux21_ni $PINS Y=nx9853 A0=camera_module_cache_ram_122__3 A1=nx35338
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__3 dffr $PINS Q=camera_module_cache_ram_106__3
+ QB=#dummy[1477] D=nx9863 CLK=clk R=rst
Xix9864 mux21_ni $PINS Y=nx9863 A0=camera_module_cache_ram_106__3 A1=nx35338
+ S0=nx34410
Xix12543 nand04 $PINS Y=nx12542 A0=nx30725 A1=nx30733 A2=nx30741 A3=nx30749
Xix30726 aoi22 $PINS Y=nx30725 A0=camera_module_cache_ram_138__3 A1=nx36154
+ B0=camera_module_cache_ram_154__3 B1=nx36194
Xcamera_module_cache_reg_ram_138__3 dffr $PINS Q=camera_module_cache_ram_138__3
+ QB=#dummy[1478] D=nx9843 CLK=clk R=rst
Xix9844 mux21_ni $PINS Y=nx9843 A0=camera_module_cache_ram_138__3 A1=nx35340
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__3 dffr $PINS Q=camera_module_cache_ram_154__3
+ QB=#dummy[1479] D=nx9833 CLK=clk R=rst
Xix9834 mux21_ni $PINS Y=nx9833 A0=camera_module_cache_ram_154__3 A1=nx35340
+ S0=nx34398
Xix30734 aoi22 $PINS Y=nx30733 A0=camera_module_cache_ram_186__3 A1=nx36234
+ B0=camera_module_cache_ram_170__3 B1=nx36274
Xcamera_module_cache_reg_ram_186__3 dffr $PINS Q=camera_module_cache_ram_186__3
+ QB=#dummy[1480] D=nx9813 CLK=clk R=rst
Xix9814 mux21_ni $PINS Y=nx9813 A0=camera_module_cache_ram_186__3 A1=nx35340
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__3 dffr $PINS Q=camera_module_cache_ram_170__3
+ QB=#dummy[1481] D=nx9823 CLK=clk R=rst
Xix9824 mux21_ni $PINS Y=nx9823 A0=camera_module_cache_ram_170__3 A1=nx35340
+ S0=nx34394
Xix30742 aoi22 $PINS Y=nx30741 A0=camera_module_cache_ram_202__3 A1=nx36314
+ B0=camera_module_cache_ram_218__3 B1=nx36354
Xcamera_module_cache_reg_ram_202__3 dffr $PINS Q=camera_module_cache_ram_202__3
+ QB=#dummy[1482] D=nx9803 CLK=clk R=rst
Xix9804 mux21_ni $PINS Y=nx9803 A0=camera_module_cache_ram_202__3 A1=nx35340
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__3 dffr $PINS Q=camera_module_cache_ram_218__3
+ QB=#dummy[1483] D=nx9793 CLK=clk R=rst
Xix9794 mux21_ni $PINS Y=nx9793 A0=camera_module_cache_ram_218__3 A1=nx35340
+ S0=nx34382
Xix30750 aoi22 $PINS Y=nx30749 A0=camera_module_cache_ram_234__3 A1=nx36394
+ B0=camera_module_cache_ram_250__3 B1=nx36434
Xcamera_module_cache_reg_ram_234__3 dffr $PINS Q=camera_module_cache_ram_234__3
+ QB=#dummy[1484] D=nx9783 CLK=clk R=rst
Xix9784 mux21_ni $PINS Y=nx9783 A0=camera_module_cache_ram_234__3 A1=nx35340
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__3 dffr $PINS Q=camera_module_cache_ram_250__3
+ QB=#dummy[1485] D=nx9773 CLK=clk R=rst
Xix9774 mux21_ni $PINS Y=nx9773 A0=camera_module_cache_ram_250__3 A1=nx35342
+ S0=nx34374
Xix30758 oai21 $PINS Y=nx30757 A0=nx12458 A1=nx12380 B0=nx36492
Xix12459 nand04 $PINS Y=nx12458 A0=nx30760 A1=nx30768 A2=nx30776 A3=nx30784
Xix30761 aoi22 $PINS Y=nx30760 A0=camera_module_cache_ram_11__3 A1=nx35834
+ B0=camera_module_cache_ram_27__3 B1=nx35874
Xcamera_module_cache_reg_ram_11__3 dffr $PINS Q=camera_module_cache_ram_11__3
+ QB=#dummy[1486] D=nx9763 CLK=clk R=rst
Xix9764 mux21_ni $PINS Y=nx9763 A0=camera_module_cache_ram_11__3 A1=nx35342
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__3 dffr $PINS Q=camera_module_cache_ram_27__3
+ QB=#dummy[1487] D=nx9753 CLK=clk R=rst
Xix9754 mux21_ni $PINS Y=nx9753 A0=camera_module_cache_ram_27__3 A1=nx35342
+ S0=nx34360
Xix30769 aoi22 $PINS Y=nx30768 A0=camera_module_cache_ram_43__3 A1=nx35914
+ B0=camera_module_cache_ram_59__3 B1=nx35954
Xcamera_module_cache_reg_ram_43__3 dffr $PINS Q=camera_module_cache_ram_43__3
+ QB=#dummy[1488] D=nx9743 CLK=clk R=rst
Xix9744 mux21_ni $PINS Y=nx9743 A0=camera_module_cache_ram_43__3 A1=nx35342
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__3 dffr $PINS Q=camera_module_cache_ram_59__3
+ QB=#dummy[1489] D=nx9733 CLK=clk R=rst
Xix9734 mux21_ni $PINS Y=nx9733 A0=camera_module_cache_ram_59__3 A1=nx35342
+ S0=nx34352
Xix30777 aoi22 $PINS Y=nx30776 A0=camera_module_cache_ram_75__3 A1=nx35994
+ B0=camera_module_cache_ram_91__3 B1=nx36034
Xcamera_module_cache_reg_ram_75__3 dffr $PINS Q=camera_module_cache_ram_75__3
+ QB=#dummy[1490] D=nx9723 CLK=clk R=rst
Xix9724 mux21_ni $PINS Y=nx9723 A0=camera_module_cache_ram_75__3 A1=nx35342
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__3 dffr $PINS Q=camera_module_cache_ram_91__3
+ QB=#dummy[1491] D=nx9713 CLK=clk R=rst
Xix9714 mux21_ni $PINS Y=nx9713 A0=camera_module_cache_ram_91__3 A1=nx35342
+ S0=nx34344
Xix30785 aoi22 $PINS Y=nx30784 A0=camera_module_cache_ram_123__3 A1=nx36074
+ B0=camera_module_cache_ram_107__3 B1=nx36114
Xcamera_module_cache_reg_ram_123__3 dffr $PINS Q=camera_module_cache_ram_123__3
+ QB=#dummy[1492] D=nx9693 CLK=clk R=rst
Xix9694 mux21_ni $PINS Y=nx9693 A0=camera_module_cache_ram_123__3 A1=nx35344
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__3 dffr $PINS Q=camera_module_cache_ram_107__3
+ QB=#dummy[1493] D=nx9703 CLK=clk R=rst
Xix9704 mux21_ni $PINS Y=nx9703 A0=camera_module_cache_ram_107__3 A1=nx35344
+ S0=nx34340
Xix12381 nand04 $PINS Y=nx12380 A0=nx30793 A1=nx30801 A2=nx30809 A3=nx30817
Xix30794 aoi22 $PINS Y=nx30793 A0=camera_module_cache_ram_139__3 A1=nx36154
+ B0=camera_module_cache_ram_155__3 B1=nx36194
Xcamera_module_cache_reg_ram_139__3 dffr $PINS Q=camera_module_cache_ram_139__3
+ QB=#dummy[1494] D=nx9683 CLK=clk R=rst
Xix9684 mux21_ni $PINS Y=nx9683 A0=camera_module_cache_ram_139__3 A1=nx35344
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__3 dffr $PINS Q=camera_module_cache_ram_155__3
+ QB=#dummy[1495] D=nx9673 CLK=clk R=rst
Xix9674 mux21_ni $PINS Y=nx9673 A0=camera_module_cache_ram_155__3 A1=nx35344
+ S0=nx34328
Xix30802 aoi22 $PINS Y=nx30801 A0=camera_module_cache_ram_187__3 A1=nx36234
+ B0=camera_module_cache_ram_171__3 B1=nx36274
Xcamera_module_cache_reg_ram_187__3 dffr $PINS Q=camera_module_cache_ram_187__3
+ QB=#dummy[1496] D=nx9653 CLK=clk R=rst
Xix9654 mux21_ni $PINS Y=nx9653 A0=camera_module_cache_ram_187__3 A1=nx35344
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__3 dffr $PINS Q=camera_module_cache_ram_171__3
+ QB=#dummy[1497] D=nx9663 CLK=clk R=rst
Xix9664 mux21_ni $PINS Y=nx9663 A0=camera_module_cache_ram_171__3 A1=nx35344
+ S0=nx34324
Xix30810 aoi22 $PINS Y=nx30809 A0=camera_module_cache_ram_203__3 A1=nx36314
+ B0=camera_module_cache_ram_219__3 B1=nx36354
Xcamera_module_cache_reg_ram_203__3 dffr $PINS Q=camera_module_cache_ram_203__3
+ QB=#dummy[1498] D=nx9643 CLK=clk R=rst
Xix9644 mux21_ni $PINS Y=nx9643 A0=camera_module_cache_ram_203__3 A1=nx35344
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__3 dffr $PINS Q=camera_module_cache_ram_219__3
+ QB=#dummy[1499] D=nx9633 CLK=clk R=rst
Xix9634 mux21_ni $PINS Y=nx9633 A0=camera_module_cache_ram_219__3 A1=nx35346
+ S0=nx34312
Xix30818 aoi22 $PINS Y=nx30817 A0=camera_module_cache_ram_235__3 A1=nx36394
+ B0=camera_module_cache_ram_251__3 B1=nx36434
Xcamera_module_cache_reg_ram_235__3 dffr $PINS Q=camera_module_cache_ram_235__3
+ QB=#dummy[1500] D=nx9623 CLK=clk R=rst
Xix9624 mux21_ni $PINS Y=nx9623 A0=camera_module_cache_ram_235__3 A1=nx35346
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__3 dffr $PINS Q=camera_module_cache_ram_251__3
+ QB=#dummy[1501] D=nx9613 CLK=clk R=rst
Xix9614 mux21_ni $PINS Y=nx9613 A0=camera_module_cache_ram_251__3 A1=nx35346
+ S0=nx34304
Xix12303 nand04 $PINS Y=nx12302 A0=nx30826 A1=nx30894 A2=nx30962 A3=nx31030
Xix30827 oai21 $PINS Y=nx30826 A0=nx12292 A1=nx12214 B0=nx36508
Xix12293 nand04 $PINS Y=nx12292 A0=nx30829 A1=nx30837 A2=nx30845 A3=nx30853
Xix30830 aoi22 $PINS Y=nx30829 A0=camera_module_cache_ram_12__3 A1=nx35834
+ B0=camera_module_cache_ram_28__3 B1=nx35874
Xcamera_module_cache_reg_ram_12__3 dffr $PINS Q=camera_module_cache_ram_12__3
+ QB=#dummy[1502] D=nx9603 CLK=clk R=rst
Xix9604 mux21_ni $PINS Y=nx9603 A0=nx35346 A1=camera_module_cache_ram_12__3
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__3 dffr $PINS Q=camera_module_cache_ram_28__3
+ QB=#dummy[1503] D=nx9593 CLK=clk R=rst
Xix9594 mux21_ni $PINS Y=nx9593 A0=nx35346 A1=camera_module_cache_ram_28__3
+ S0=nx36510
Xix30838 aoi22 $PINS Y=nx30837 A0=camera_module_cache_ram_44__3 A1=nx35914
+ B0=camera_module_cache_ram_60__3 B1=nx35954
Xcamera_module_cache_reg_ram_44__3 dffr $PINS Q=camera_module_cache_ram_44__3
+ QB=#dummy[1504] D=nx9583 CLK=clk R=rst
Xix9584 mux21_ni $PINS Y=nx9583 A0=nx35346 A1=camera_module_cache_ram_44__3
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__3 dffr $PINS Q=camera_module_cache_ram_60__3
+ QB=#dummy[1505] D=nx9573 CLK=clk R=rst
Xix9574 mux21_ni $PINS Y=nx9573 A0=nx35346 A1=camera_module_cache_ram_60__3
+ S0=nx36518
Xix30846 aoi22 $PINS Y=nx30845 A0=camera_module_cache_ram_76__3 A1=nx35994
+ B0=camera_module_cache_ram_92__3 B1=nx36034
Xcamera_module_cache_reg_ram_76__3 dffr $PINS Q=camera_module_cache_ram_76__3
+ QB=#dummy[1506] D=nx9563 CLK=clk R=rst
Xix9564 mux21_ni $PINS Y=nx9563 A0=nx35348 A1=camera_module_cache_ram_76__3
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__3 dffr $PINS Q=camera_module_cache_ram_92__3
+ QB=#dummy[1507] D=nx9553 CLK=clk R=rst
Xix9554 mux21_ni $PINS Y=nx9553 A0=nx35348 A1=camera_module_cache_ram_92__3
+ S0=nx36526
Xix30854 aoi22 $PINS Y=nx30853 A0=camera_module_cache_ram_124__3 A1=nx36074
+ B0=camera_module_cache_ram_108__3 B1=nx36114
Xcamera_module_cache_reg_ram_124__3 dffr $PINS Q=camera_module_cache_ram_124__3
+ QB=#dummy[1508] D=nx9533 CLK=clk R=rst
Xix9534 mux21_ni $PINS Y=nx9533 A0=nx35348 A1=camera_module_cache_ram_124__3
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__3 dffr $PINS Q=camera_module_cache_ram_108__3
+ QB=#dummy[1509] D=nx9543 CLK=clk R=rst
Xix9544 mux21_ni $PINS Y=nx9543 A0=nx35348 A1=camera_module_cache_ram_108__3
+ S0=nx36534
Xix12215 nand04 $PINS Y=nx12214 A0=nx30862 A1=nx30870 A2=nx30878 A3=nx30886
Xix30863 aoi22 $PINS Y=nx30862 A0=camera_module_cache_ram_140__3 A1=nx36154
+ B0=camera_module_cache_ram_156__3 B1=nx36194
Xcamera_module_cache_reg_ram_140__3 dffr $PINS Q=camera_module_cache_ram_140__3
+ QB=#dummy[1510] D=nx9523 CLK=clk R=rst
Xix9524 mux21_ni $PINS Y=nx9523 A0=nx35348 A1=camera_module_cache_ram_140__3
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__3 dffr $PINS Q=camera_module_cache_ram_156__3
+ QB=#dummy[1511] D=nx9513 CLK=clk R=rst
Xix9514 mux21_ni $PINS Y=nx9513 A0=nx35348 A1=camera_module_cache_ram_156__3
+ S0=nx36542
Xix30871 aoi22 $PINS Y=nx30870 A0=camera_module_cache_ram_188__3 A1=nx36234
+ B0=camera_module_cache_ram_172__3 B1=nx36274
Xcamera_module_cache_reg_ram_188__3 dffr $PINS Q=camera_module_cache_ram_188__3
+ QB=#dummy[1512] D=nx9493 CLK=clk R=rst
Xix9494 mux21_ni $PINS Y=nx9493 A0=nx35348 A1=camera_module_cache_ram_188__3
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__3 dffr $PINS Q=camera_module_cache_ram_172__3
+ QB=#dummy[1513] D=nx9503 CLK=clk R=rst
Xix9504 mux21_ni $PINS Y=nx9503 A0=nx35350 A1=camera_module_cache_ram_172__3
+ S0=nx36550
Xix30879 aoi22 $PINS Y=nx30878 A0=camera_module_cache_ram_204__3 A1=nx36314
+ B0=camera_module_cache_ram_220__3 B1=nx36354
Xcamera_module_cache_reg_ram_204__3 dffr $PINS Q=camera_module_cache_ram_204__3
+ QB=#dummy[1514] D=nx9483 CLK=clk R=rst
Xix9484 mux21_ni $PINS Y=nx9483 A0=nx35350 A1=camera_module_cache_ram_204__3
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__3 dffr $PINS Q=camera_module_cache_ram_220__3
+ QB=#dummy[1515] D=nx9473 CLK=clk R=rst
Xix9474 mux21_ni $PINS Y=nx9473 A0=nx35350 A1=camera_module_cache_ram_220__3
+ S0=nx36558
Xix30887 aoi22 $PINS Y=nx30886 A0=camera_module_cache_ram_236__3 A1=nx36394
+ B0=camera_module_cache_ram_252__3 B1=nx36434
Xcamera_module_cache_reg_ram_236__3 dffr $PINS Q=camera_module_cache_ram_236__3
+ QB=#dummy[1516] D=nx9463 CLK=clk R=rst
Xix9464 mux21_ni $PINS Y=nx9463 A0=nx35350 A1=camera_module_cache_ram_236__3
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__3 dffr $PINS Q=camera_module_cache_ram_252__3
+ QB=#dummy[1517] D=nx9453 CLK=clk R=rst
Xix9454 mux21_ni $PINS Y=nx9453 A0=nx35350 A1=camera_module_cache_ram_252__3
+ S0=nx36566
Xix30895 oai21 $PINS Y=nx30894 A0=nx12130 A1=nx12052 B0=nx36582
Xix12131 nand04 $PINS Y=nx12130 A0=nx30897 A1=nx30905 A2=nx30913 A3=nx30921
Xix30898 aoi22 $PINS Y=nx30897 A0=camera_module_cache_ram_13__3 A1=nx35834
+ B0=camera_module_cache_ram_29__3 B1=nx35874
Xcamera_module_cache_reg_ram_13__3 dffr $PINS Q=camera_module_cache_ram_13__3
+ QB=#dummy[1518] D=nx9443 CLK=clk R=rst
Xix9444 mux21_ni $PINS Y=nx9443 A0=nx35350 A1=camera_module_cache_ram_13__3
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__3 dffr $PINS Q=camera_module_cache_ram_29__3
+ QB=#dummy[1519] D=nx9433 CLK=clk R=rst
Xix9434 mux21_ni $PINS Y=nx9433 A0=nx35350 A1=camera_module_cache_ram_29__3
+ S0=nx36584
Xix30906 aoi22 $PINS Y=nx30905 A0=camera_module_cache_ram_45__3 A1=nx35914
+ B0=camera_module_cache_ram_61__3 B1=nx35954
Xcamera_module_cache_reg_ram_45__3 dffr $PINS Q=camera_module_cache_ram_45__3
+ QB=#dummy[1520] D=nx9423 CLK=clk R=rst
Xix9424 mux21_ni $PINS Y=nx9423 A0=nx35352 A1=camera_module_cache_ram_45__3
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__3 dffr $PINS Q=camera_module_cache_ram_61__3
+ QB=#dummy[1521] D=nx9413 CLK=clk R=rst
Xix9414 mux21_ni $PINS Y=nx9413 A0=nx35352 A1=camera_module_cache_ram_61__3
+ S0=nx36592
Xix30914 aoi22 $PINS Y=nx30913 A0=camera_module_cache_ram_77__3 A1=nx35994
+ B0=camera_module_cache_ram_93__3 B1=nx36034
Xcamera_module_cache_reg_ram_77__3 dffr $PINS Q=camera_module_cache_ram_77__3
+ QB=#dummy[1522] D=nx9403 CLK=clk R=rst
Xix9404 mux21_ni $PINS Y=nx9403 A0=nx35352 A1=camera_module_cache_ram_77__3
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__3 dffr $PINS Q=camera_module_cache_ram_93__3
+ QB=#dummy[1523] D=nx9393 CLK=clk R=rst
Xix9394 mux21_ni $PINS Y=nx9393 A0=nx35352 A1=camera_module_cache_ram_93__3
+ S0=nx36600
Xix30922 aoi22 $PINS Y=nx30921 A0=camera_module_cache_ram_125__3 A1=nx36074
+ B0=camera_module_cache_ram_109__3 B1=nx36114
Xcamera_module_cache_reg_ram_125__3 dffr $PINS Q=camera_module_cache_ram_125__3
+ QB=#dummy[1524] D=nx9373 CLK=clk R=rst
Xix9374 mux21_ni $PINS Y=nx9373 A0=nx35352 A1=camera_module_cache_ram_125__3
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__3 dffr $PINS Q=camera_module_cache_ram_109__3
+ QB=#dummy[1525] D=nx9383 CLK=clk R=rst
Xix9384 mux21_ni $PINS Y=nx9383 A0=nx35352 A1=camera_module_cache_ram_109__3
+ S0=nx36608
Xix12053 nand04 $PINS Y=nx12052 A0=nx30930 A1=nx30938 A2=nx30946 A3=nx30954
Xix30931 aoi22 $PINS Y=nx30930 A0=camera_module_cache_ram_141__3 A1=nx36154
+ B0=camera_module_cache_ram_157__3 B1=nx36194
Xcamera_module_cache_reg_ram_141__3 dffr $PINS Q=camera_module_cache_ram_141__3
+ QB=#dummy[1526] D=nx9363 CLK=clk R=rst
Xix9364 mux21_ni $PINS Y=nx9363 A0=nx35352 A1=camera_module_cache_ram_141__3
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__3 dffr $PINS Q=camera_module_cache_ram_157__3
+ QB=#dummy[1527] D=nx9353 CLK=clk R=rst
Xix9354 mux21_ni $PINS Y=nx9353 A0=nx35354 A1=camera_module_cache_ram_157__3
+ S0=nx36616
Xix30939 aoi22 $PINS Y=nx30938 A0=camera_module_cache_ram_189__3 A1=nx36234
+ B0=camera_module_cache_ram_173__3 B1=nx36274
Xcamera_module_cache_reg_ram_189__3 dffr $PINS Q=camera_module_cache_ram_189__3
+ QB=#dummy[1528] D=nx9333 CLK=clk R=rst
Xix9334 mux21_ni $PINS Y=nx9333 A0=nx35354 A1=camera_module_cache_ram_189__3
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__3 dffr $PINS Q=camera_module_cache_ram_173__3
+ QB=#dummy[1529] D=nx9343 CLK=clk R=rst
Xix9344 mux21_ni $PINS Y=nx9343 A0=nx35354 A1=camera_module_cache_ram_173__3
+ S0=nx36624
Xix30947 aoi22 $PINS Y=nx30946 A0=camera_module_cache_ram_205__3 A1=nx36314
+ B0=camera_module_cache_ram_221__3 B1=nx36354
Xcamera_module_cache_reg_ram_205__3 dffr $PINS Q=camera_module_cache_ram_205__3
+ QB=#dummy[1530] D=nx9323 CLK=clk R=rst
Xix9324 mux21_ni $PINS Y=nx9323 A0=nx35354 A1=camera_module_cache_ram_205__3
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__3 dffr $PINS Q=camera_module_cache_ram_221__3
+ QB=#dummy[1531] D=nx9313 CLK=clk R=rst
Xix9314 mux21_ni $PINS Y=nx9313 A0=nx35354 A1=camera_module_cache_ram_221__3
+ S0=nx36632
Xix30955 aoi22 $PINS Y=nx30954 A0=camera_module_cache_ram_237__3 A1=nx36394
+ B0=camera_module_cache_ram_253__3 B1=nx36434
Xcamera_module_cache_reg_ram_237__3 dffr $PINS Q=camera_module_cache_ram_237__3
+ QB=#dummy[1532] D=nx9303 CLK=clk R=rst
Xix9304 mux21_ni $PINS Y=nx9303 A0=nx35354 A1=camera_module_cache_ram_237__3
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__3 dffr $PINS Q=camera_module_cache_ram_253__3
+ QB=#dummy[1533] D=nx9293 CLK=clk R=rst
Xix9294 mux21_ni $PINS Y=nx9293 A0=nx35354 A1=camera_module_cache_ram_253__3
+ S0=nx36640
Xix30963 oai21 $PINS Y=nx30962 A0=nx11966 A1=nx11888 B0=nx36656
Xix11967 nand04 $PINS Y=nx11966 A0=nx30965 A1=nx30973 A2=nx30981 A3=nx30989
Xix30966 aoi22 $PINS Y=nx30965 A0=camera_module_cache_ram_14__3 A1=nx35836
+ B0=camera_module_cache_ram_30__3 B1=nx35876
Xcamera_module_cache_reg_ram_14__3 dffr $PINS Q=camera_module_cache_ram_14__3
+ QB=#dummy[1534] D=nx9283 CLK=clk R=rst
Xix9284 mux21_ni $PINS Y=nx9283 A0=nx35356 A1=camera_module_cache_ram_14__3
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__3 dffr $PINS Q=camera_module_cache_ram_30__3
+ QB=#dummy[1535] D=nx9273 CLK=clk R=rst
Xix9274 mux21_ni $PINS Y=nx9273 A0=nx35356 A1=camera_module_cache_ram_30__3
+ S0=nx36658
Xix30974 aoi22 $PINS Y=nx30973 A0=camera_module_cache_ram_46__3 A1=nx35916
+ B0=camera_module_cache_ram_62__3 B1=nx35956
Xcamera_module_cache_reg_ram_46__3 dffr $PINS Q=camera_module_cache_ram_46__3
+ QB=#dummy[1536] D=nx9263 CLK=clk R=rst
Xix9264 mux21_ni $PINS Y=nx9263 A0=nx35356 A1=camera_module_cache_ram_46__3
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__3 dffr $PINS Q=camera_module_cache_ram_62__3
+ QB=#dummy[1537] D=nx9253 CLK=clk R=rst
Xix9254 mux21_ni $PINS Y=nx9253 A0=nx35356 A1=camera_module_cache_ram_62__3
+ S0=nx36666
Xix30982 aoi22 $PINS Y=nx30981 A0=camera_module_cache_ram_78__3 A1=nx35996
+ B0=camera_module_cache_ram_94__3 B1=nx36036
Xcamera_module_cache_reg_ram_78__3 dffr $PINS Q=camera_module_cache_ram_78__3
+ QB=#dummy[1538] D=nx9243 CLK=clk R=rst
Xix9244 mux21_ni $PINS Y=nx9243 A0=nx35356 A1=camera_module_cache_ram_78__3
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__3 dffr $PINS Q=camera_module_cache_ram_94__3
+ QB=#dummy[1539] D=nx9233 CLK=clk R=rst
Xix9234 mux21_ni $PINS Y=nx9233 A0=nx35356 A1=camera_module_cache_ram_94__3
+ S0=nx36674
Xix30990 aoi22 $PINS Y=nx30989 A0=camera_module_cache_ram_126__3 A1=nx36076
+ B0=camera_module_cache_ram_110__3 B1=nx36116
Xcamera_module_cache_reg_ram_126__3 dffr $PINS Q=camera_module_cache_ram_126__3
+ QB=#dummy[1540] D=nx9213 CLK=clk R=rst
Xix9214 mux21_ni $PINS Y=nx9213 A0=nx35356 A1=camera_module_cache_ram_126__3
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__3 dffr $PINS Q=camera_module_cache_ram_110__3
+ QB=#dummy[1541] D=nx9223 CLK=clk R=rst
Xix9224 mux21_ni $PINS Y=nx9223 A0=nx35358 A1=camera_module_cache_ram_110__3
+ S0=nx36682
Xix11889 nand04 $PINS Y=nx11888 A0=nx30998 A1=nx31006 A2=nx31014 A3=nx31022
Xix30999 aoi22 $PINS Y=nx30998 A0=camera_module_cache_ram_142__3 A1=nx36156
+ B0=camera_module_cache_ram_158__3 B1=nx36196
Xcamera_module_cache_reg_ram_142__3 dffr $PINS Q=camera_module_cache_ram_142__3
+ QB=#dummy[1542] D=nx9203 CLK=clk R=rst
Xix9204 mux21_ni $PINS Y=nx9203 A0=nx35358 A1=camera_module_cache_ram_142__3
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__3 dffr $PINS Q=camera_module_cache_ram_158__3
+ QB=#dummy[1543] D=nx9193 CLK=clk R=rst
Xix9194 mux21_ni $PINS Y=nx9193 A0=nx35358 A1=camera_module_cache_ram_158__3
+ S0=nx36690
Xix31007 aoi22 $PINS Y=nx31006 A0=camera_module_cache_ram_190__3 A1=nx36236
+ B0=camera_module_cache_ram_174__3 B1=nx36276
Xcamera_module_cache_reg_ram_190__3 dffr $PINS Q=camera_module_cache_ram_190__3
+ QB=#dummy[1544] D=nx9173 CLK=clk R=rst
Xix9174 mux21_ni $PINS Y=nx9173 A0=nx35358 A1=camera_module_cache_ram_190__3
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__3 dffr $PINS Q=camera_module_cache_ram_174__3
+ QB=#dummy[1545] D=nx9183 CLK=clk R=rst
Xix9184 mux21_ni $PINS Y=nx9183 A0=nx35358 A1=camera_module_cache_ram_174__3
+ S0=nx36698
Xix31015 aoi22 $PINS Y=nx31014 A0=camera_module_cache_ram_206__3 A1=nx36316
+ B0=camera_module_cache_ram_222__3 B1=nx36356
Xcamera_module_cache_reg_ram_206__3 dffr $PINS Q=camera_module_cache_ram_206__3
+ QB=#dummy[1546] D=nx9163 CLK=clk R=rst
Xix9164 mux21_ni $PINS Y=nx9163 A0=nx35358 A1=camera_module_cache_ram_206__3
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__3 dffr $PINS Q=camera_module_cache_ram_222__3
+ QB=#dummy[1547] D=nx9153 CLK=clk R=rst
Xix9154 mux21_ni $PINS Y=nx9153 A0=nx35358 A1=camera_module_cache_ram_222__3
+ S0=nx36706
Xix31023 aoi22 $PINS Y=nx31022 A0=camera_module_cache_ram_238__3 A1=nx36396
+ B0=camera_module_cache_ram_254__3 B1=nx36436
Xcamera_module_cache_reg_ram_238__3 dffr $PINS Q=camera_module_cache_ram_238__3
+ QB=#dummy[1548] D=nx9143 CLK=clk R=rst
Xix9144 mux21_ni $PINS Y=nx9143 A0=nx35360 A1=camera_module_cache_ram_238__3
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__3 dffr $PINS Q=camera_module_cache_ram_254__3
+ QB=#dummy[1549] D=nx9133 CLK=clk R=rst
Xix9134 mux21_ni $PINS Y=nx9133 A0=nx35360 A1=camera_module_cache_ram_254__3
+ S0=nx36714
Xix31031 oai21 $PINS Y=nx31030 A0=nx11804 A1=nx11726 B0=nx36730
Xix11805 nand04 $PINS Y=nx11804 A0=nx31033 A1=nx31041 A2=nx31049 A3=nx31057
Xix31034 aoi22 $PINS Y=nx31033 A0=camera_module_cache_ram_15__3 A1=nx35836
+ B0=camera_module_cache_ram_31__3 B1=nx35876
Xcamera_module_cache_reg_ram_15__3 dffr $PINS Q=camera_module_cache_ram_15__3
+ QB=#dummy[1550] D=nx9123 CLK=clk R=rst
Xix9124 mux21_ni $PINS Y=nx9123 A0=nx35360 A1=camera_module_cache_ram_15__3
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__3 dffr $PINS Q=camera_module_cache_ram_31__3
+ QB=#dummy[1551] D=nx9113 CLK=clk R=rst
Xix9114 mux21_ni $PINS Y=nx9113 A0=nx35360 A1=camera_module_cache_ram_31__3
+ S0=nx36732
Xix31042 aoi22 $PINS Y=nx31041 A0=camera_module_cache_ram_47__3 A1=nx35916
+ B0=camera_module_cache_ram_63__3 B1=nx35956
Xcamera_module_cache_reg_ram_47__3 dffr $PINS Q=camera_module_cache_ram_47__3
+ QB=#dummy[1552] D=nx9103 CLK=clk R=rst
Xix9104 mux21_ni $PINS Y=nx9103 A0=nx35360 A1=camera_module_cache_ram_47__3
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__3 dffr $PINS Q=camera_module_cache_ram_63__3
+ QB=#dummy[1553] D=nx9093 CLK=clk R=rst
Xix9094 mux21_ni $PINS Y=nx9093 A0=nx35360 A1=camera_module_cache_ram_63__3
+ S0=nx36740
Xix31050 aoi22 $PINS Y=nx31049 A0=camera_module_cache_ram_79__3 A1=nx35996
+ B0=camera_module_cache_ram_95__3 B1=nx36036
Xcamera_module_cache_reg_ram_79__3 dffr $PINS Q=camera_module_cache_ram_79__3
+ QB=#dummy[1554] D=nx9083 CLK=clk R=rst
Xix9084 mux21_ni $PINS Y=nx9083 A0=nx35360 A1=camera_module_cache_ram_79__3
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__3 dffr $PINS Q=camera_module_cache_ram_95__3
+ QB=#dummy[1555] D=nx9073 CLK=clk R=rst
Xix9074 mux21_ni $PINS Y=nx9073 A0=nx35362 A1=camera_module_cache_ram_95__3
+ S0=nx36748
Xix31058 aoi22 $PINS Y=nx31057 A0=camera_module_cache_ram_127__3 A1=nx36076
+ B0=camera_module_cache_ram_111__3 B1=nx36116
Xcamera_module_cache_reg_ram_127__3 dffr $PINS Q=camera_module_cache_ram_127__3
+ QB=#dummy[1556] D=nx9053 CLK=clk R=rst
Xix9054 mux21_ni $PINS Y=nx9053 A0=nx35362 A1=camera_module_cache_ram_127__3
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__3 dffr $PINS Q=camera_module_cache_ram_111__3
+ QB=#dummy[1557] D=nx9063 CLK=clk R=rst
Xix9064 mux21_ni $PINS Y=nx9063 A0=nx35362 A1=camera_module_cache_ram_111__3
+ S0=nx36756
Xix11727 nand04 $PINS Y=nx11726 A0=nx31066 A1=nx31074 A2=nx31082 A3=nx31090
Xix31067 aoi22 $PINS Y=nx31066 A0=camera_module_cache_ram_143__3 A1=nx36156
+ B0=camera_module_cache_ram_159__3 B1=nx36196
Xcamera_module_cache_reg_ram_143__3 dffr $PINS Q=camera_module_cache_ram_143__3
+ QB=#dummy[1558] D=nx9043 CLK=clk R=rst
Xix9044 mux21_ni $PINS Y=nx9043 A0=nx35362 A1=camera_module_cache_ram_143__3
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__3 dffr $PINS Q=camera_module_cache_ram_159__3
+ QB=#dummy[1559] D=nx9033 CLK=clk R=rst
Xix9034 mux21_ni $PINS Y=nx9033 A0=nx35362 A1=camera_module_cache_ram_159__3
+ S0=nx36764
Xix31075 aoi22 $PINS Y=nx31074 A0=camera_module_cache_ram_191__3 A1=nx36236
+ B0=camera_module_cache_ram_175__3 B1=nx36276
Xcamera_module_cache_reg_ram_191__3 dffr $PINS Q=camera_module_cache_ram_191__3
+ QB=#dummy[1560] D=nx9013 CLK=clk R=rst
Xix9014 mux21_ni $PINS Y=nx9013 A0=nx35362 A1=camera_module_cache_ram_191__3
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__3 dffr $PINS Q=camera_module_cache_ram_175__3
+ QB=#dummy[1561] D=nx9023 CLK=clk R=rst
Xix9024 mux21_ni $PINS Y=nx9023 A0=nx35362 A1=camera_module_cache_ram_175__3
+ S0=nx36772
Xix31083 aoi22 $PINS Y=nx31082 A0=camera_module_cache_ram_207__3 A1=nx36316
+ B0=camera_module_cache_ram_223__3 B1=nx36356
Xcamera_module_cache_reg_ram_207__3 dffr $PINS Q=camera_module_cache_ram_207__3
+ QB=#dummy[1562] D=nx9003 CLK=clk R=rst
Xix9004 mux21_ni $PINS Y=nx9003 A0=nx35364 A1=camera_module_cache_ram_207__3
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__3 dffr $PINS Q=camera_module_cache_ram_223__3
+ QB=#dummy[1563] D=nx8993 CLK=clk R=rst
Xix8994 mux21_ni $PINS Y=nx8993 A0=nx35364 A1=camera_module_cache_ram_223__3
+ S0=nx36780
Xix31091 aoi22 $PINS Y=nx31090 A0=camera_module_cache_ram_239__3 A1=nx36396
+ B0=camera_module_cache_ram_255__3 B1=nx36436
Xcamera_module_cache_reg_ram_239__3 dffr $PINS Q=camera_module_cache_ram_239__3
+ QB=#dummy[1564] D=nx8983 CLK=clk R=rst
Xix8984 mux21_ni $PINS Y=nx8983 A0=nx35364 A1=camera_module_cache_ram_239__3
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__3 dffr $PINS Q=camera_module_cache_ram_255__3
+ QB=#dummy[1565] D=nx8973 CLK=clk R=rst
Xix8974 mux21_ni $PINS Y=nx8973 A0=nx35364 A1=camera_module_cache_ram_255__3
+ S0=nx36788
Xcamera_module_algo_module_pixel_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_pixel_value_5 QB=nx32240 D=nx16673 CLK=clk
Xix16674 mux21_ni $PINS Y=nx16673 A0=nx19834
+ A1=camera_module_algo_module_pixel_value_5 S0=nx22665
Xix31107 mux21_ni $PINS Y=nx31106 A0=nx31108 A1=nx35676 S0=nx36792
Xix31109 nor04 $PINS Y=nx31108 A0=nx19814 A1=nx19160 A2=nx18504 A3=nx17850
Xix19815 nand04 $PINS Y=nx19814 A0=nx31111 A1=nx31217 A2=nx31285 A3=nx31353
Xix31112 oai21 $PINS Y=nx31111 A0=nx19804 A1=nx19726 B0=nx36448
Xix19805 nand04 $PINS Y=nx19804 A0=nx31114 A1=nx31160 A2=nx31168 A3=nx31176
Xix31115 aoi22 $PINS Y=nx31114 A0=camera_module_cache_ram_0__5 A1=nx35836
+ B0=camera_module_cache_ram_16__5 B1=nx35876
Xcamera_module_cache_reg_ram_0__5 dffr $PINS Q=camera_module_cache_ram_0__5
+ QB=#dummy[1566] D=nx16663 CLK=clk R=rst
Xix16664 mux21_ni $PINS Y=nx16663 A0=camera_module_cache_ram_0__5 A1=nx35444
+ S0=nx35134
Xix17197 oai221 $PINS Y=nx17196 A0=nx34076 A1=nx31119 B0=nx31135 B1=nx35714
+ C0=nx31138
Xnvm_module_tri_dataout_125 tri01 $PINS Y=nvm_data_125 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_117 tri01 $PINS Y=nvm_data_117 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_109 tri01 $PINS Y=nvm_data_109 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_101 tri01 $PINS Y=nvm_data_101 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_93 tri01 $PINS Y=nvm_data_93 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_85 tri01 $PINS Y=nvm_data_85 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_77 tri01 $PINS Y=nvm_data_77 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_69 tri01 $PINS Y=nvm_data_69 A=nx22549
+ E=nvm_module_GND0
Xix31136 inv01 $PINS Y=nx31135 A=nvm_data_5
Xnvm_module_tri_dataout_5 tri01 $PINS Y=nvm_data_5 A=nx22549 E=nvm_module_GND0
Xix31139 nand02 $PINS Y=nx31138 A0=nx34076 A1=nx17130
Xnvm_module_tri_dataout_61 tri01 $PINS Y=nvm_data_61 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_53 tri01 $PINS Y=nvm_data_53 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_45 tri01 $PINS Y=nvm_data_45 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_37 tri01 $PINS Y=nvm_data_37 A=nx22549
+ E=nvm_module_GND0
Xix17099 oai22 $PINS Y=nx17098 A0=nx34108 A1=nx31149 B0=nx34094 B1=nx31153
Xnvm_module_tri_dataout_29 tri01 $PINS Y=nvm_data_29 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_21 tri01 $PINS Y=nvm_data_21 A=nx22549
+ E=nvm_module_GND0
Xix31154 nand02 $PINS Y=nx31153 A0=nvm_data_13 A1=nx34108
Xnvm_module_tri_dataout_13 tri01 $PINS Y=nvm_data_13 A=nx22549
+ E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__5 dffr $PINS Q=camera_module_cache_ram_16__5
+ QB=#dummy[1567] D=nx16653 CLK=clk R=rst
Xix16654 mux21_ni $PINS Y=nx16653 A0=camera_module_cache_ram_16__5 A1=nx35444
+ S0=nx35130
Xix31161 aoi22 $PINS Y=nx31160 A0=camera_module_cache_ram_32__5 A1=nx35916
+ B0=camera_module_cache_ram_48__5 B1=nx35956
Xcamera_module_cache_reg_ram_32__5 dffr $PINS Q=camera_module_cache_ram_32__5
+ QB=#dummy[1568] D=nx16643 CLK=clk R=rst
Xix16644 mux21_ni $PINS Y=nx16643 A0=camera_module_cache_ram_32__5 A1=nx35444
+ S0=nx35126
Xcamera_module_cache_reg_ram_48__5 dffr $PINS Q=camera_module_cache_ram_48__5
+ QB=#dummy[1569] D=nx16633 CLK=clk R=rst
Xix16634 mux21_ni $PINS Y=nx16633 A0=camera_module_cache_ram_48__5 A1=nx35444
+ S0=nx35122
Xix31169 aoi22 $PINS Y=nx31168 A0=camera_module_cache_ram_64__5 A1=nx35996
+ B0=camera_module_cache_ram_80__5 B1=nx36036
Xcamera_module_cache_reg_ram_64__5 dffr $PINS Q=camera_module_cache_ram_64__5
+ QB=#dummy[1570] D=nx16623 CLK=clk R=rst
Xix16624 mux21_ni $PINS Y=nx16623 A0=camera_module_cache_ram_64__5 A1=nx35444
+ S0=nx35118
Xcamera_module_cache_reg_ram_80__5 dffr $PINS Q=camera_module_cache_ram_80__5
+ QB=#dummy[1571] D=nx16613 CLK=clk R=rst
Xix16614 mux21_ni $PINS Y=nx16613 A0=camera_module_cache_ram_80__5 A1=nx35444
+ S0=nx35114
Xix31177 aoi22 $PINS Y=nx31176 A0=camera_module_cache_ram_112__5 A1=nx36076
+ B0=camera_module_cache_ram_96__5 B1=nx36116
Xcamera_module_cache_reg_ram_112__5 dffr $PINS Q=camera_module_cache_ram_112__5
+ QB=#dummy[1572] D=nx16593 CLK=clk R=rst
Xix16594 mux21_ni $PINS Y=nx16593 A0=camera_module_cache_ram_112__5 A1=nx35444
+ S0=nx35106
Xcamera_module_cache_reg_ram_96__5 dffr $PINS Q=camera_module_cache_ram_96__5
+ QB=#dummy[1573] D=nx16603 CLK=clk R=rst
Xix16604 mux21_ni $PINS Y=nx16603 A0=camera_module_cache_ram_96__5 A1=nx35446
+ S0=nx35110
Xix19727 nand04 $PINS Y=nx19726 A0=nx31185 A1=nx31193 A2=nx31201 A3=nx31209
Xix31186 aoi22 $PINS Y=nx31185 A0=camera_module_cache_ram_128__5 A1=nx36156
+ B0=camera_module_cache_ram_144__5 B1=nx36196
Xcamera_module_cache_reg_ram_128__5 dffr $PINS Q=camera_module_cache_ram_128__5
+ QB=#dummy[1574] D=nx16583 CLK=clk R=rst
Xix16584 mux21_ni $PINS Y=nx16583 A0=camera_module_cache_ram_128__5 A1=nx35446
+ S0=nx35102
Xcamera_module_cache_reg_ram_144__5 dffr $PINS Q=camera_module_cache_ram_144__5
+ QB=#dummy[1575] D=nx16573 CLK=clk R=rst
Xix16574 mux21_ni $PINS Y=nx16573 A0=camera_module_cache_ram_144__5 A1=nx35446
+ S0=nx35098
Xix31194 aoi22 $PINS Y=nx31193 A0=camera_module_cache_ram_176__5 A1=nx36236
+ B0=camera_module_cache_ram_160__5 B1=nx36276
Xcamera_module_cache_reg_ram_176__5 dffr $PINS Q=camera_module_cache_ram_176__5
+ QB=#dummy[1576] D=nx16553 CLK=clk R=rst
Xix16554 mux21_ni $PINS Y=nx16553 A0=camera_module_cache_ram_176__5 A1=nx35446
+ S0=nx35090
Xcamera_module_cache_reg_ram_160__5 dffr $PINS Q=camera_module_cache_ram_160__5
+ QB=#dummy[1577] D=nx16563 CLK=clk R=rst
Xix16564 mux21_ni $PINS Y=nx16563 A0=camera_module_cache_ram_160__5 A1=nx35446
+ S0=nx35094
Xix31202 aoi22 $PINS Y=nx31201 A0=camera_module_cache_ram_192__5 A1=nx36316
+ B0=camera_module_cache_ram_208__5 B1=nx36356
Xcamera_module_cache_reg_ram_192__5 dffr $PINS Q=camera_module_cache_ram_192__5
+ QB=#dummy[1578] D=nx16543 CLK=clk R=rst
Xix16544 mux21_ni $PINS Y=nx16543 A0=camera_module_cache_ram_192__5 A1=nx35446
+ S0=nx35086
Xcamera_module_cache_reg_ram_208__5 dffr $PINS Q=camera_module_cache_ram_208__5
+ QB=#dummy[1579] D=nx16533 CLK=clk R=rst
Xix16534 mux21_ni $PINS Y=nx16533 A0=camera_module_cache_ram_208__5 A1=nx35446
+ S0=nx35082
Xix31210 aoi22 $PINS Y=nx31209 A0=camera_module_cache_ram_224__5 A1=nx36396
+ B0=camera_module_cache_ram_240__5 B1=nx36436
Xcamera_module_cache_reg_ram_224__5 dffr $PINS Q=camera_module_cache_ram_224__5
+ QB=#dummy[1580] D=nx16523 CLK=clk R=rst
Xix16524 mux21_ni $PINS Y=nx16523 A0=camera_module_cache_ram_224__5 A1=nx35448
+ S0=nx35078
Xcamera_module_cache_reg_ram_240__5 dffr $PINS Q=camera_module_cache_ram_240__5
+ QB=#dummy[1581] D=nx16513 CLK=clk R=rst
Xix16514 mux21_ni $PINS Y=nx16513 A0=camera_module_cache_ram_240__5 A1=nx35448
+ S0=nx35074
Xix31218 oai21 $PINS Y=nx31217 A0=nx19642 A1=nx19564 B0=nx36452
Xix19643 nand04 $PINS Y=nx19642 A0=nx31220 A1=nx31228 A2=nx31236 A3=nx31244
Xix31221 aoi22 $PINS Y=nx31220 A0=camera_module_cache_ram_1__5 A1=nx35836
+ B0=camera_module_cache_ram_17__5 B1=nx35876
Xcamera_module_cache_reg_ram_1__5 dffr $PINS Q=camera_module_cache_ram_1__5
+ QB=#dummy[1582] D=nx16503 CLK=clk R=rst
Xix16504 mux21_ni $PINS Y=nx16503 A0=camera_module_cache_ram_1__5 A1=nx35448
+ S0=nx35064
Xcamera_module_cache_reg_ram_17__5 dffr $PINS Q=camera_module_cache_ram_17__5
+ QB=#dummy[1583] D=nx16493 CLK=clk R=rst
Xix16494 mux21_ni $PINS Y=nx16493 A0=camera_module_cache_ram_17__5 A1=nx35448
+ S0=nx35060
Xix31229 aoi22 $PINS Y=nx31228 A0=camera_module_cache_ram_33__5 A1=nx35916
+ B0=camera_module_cache_ram_49__5 B1=nx35956
Xcamera_module_cache_reg_ram_33__5 dffr $PINS Q=camera_module_cache_ram_33__5
+ QB=#dummy[1584] D=nx16483 CLK=clk R=rst
Xix16484 mux21_ni $PINS Y=nx16483 A0=camera_module_cache_ram_33__5 A1=nx35448
+ S0=nx35056
Xcamera_module_cache_reg_ram_49__5 dffr $PINS Q=camera_module_cache_ram_49__5
+ QB=#dummy[1585] D=nx16473 CLK=clk R=rst
Xix16474 mux21_ni $PINS Y=nx16473 A0=camera_module_cache_ram_49__5 A1=nx35448
+ S0=nx35052
Xix31237 aoi22 $PINS Y=nx31236 A0=camera_module_cache_ram_65__5 A1=nx35996
+ B0=camera_module_cache_ram_81__5 B1=nx36036
Xcamera_module_cache_reg_ram_65__5 dffr $PINS Q=camera_module_cache_ram_65__5
+ QB=#dummy[1586] D=nx16463 CLK=clk R=rst
Xix16464 mux21_ni $PINS Y=nx16463 A0=camera_module_cache_ram_65__5 A1=nx35448
+ S0=nx35048
Xcamera_module_cache_reg_ram_81__5 dffr $PINS Q=camera_module_cache_ram_81__5
+ QB=#dummy[1587] D=nx16453 CLK=clk R=rst
Xix16454 mux21_ni $PINS Y=nx16453 A0=camera_module_cache_ram_81__5 A1=nx35450
+ S0=nx35044
Xix31245 aoi22 $PINS Y=nx31244 A0=camera_module_cache_ram_113__5 A1=nx36076
+ B0=camera_module_cache_ram_97__5 B1=nx36116
Xcamera_module_cache_reg_ram_113__5 dffr $PINS Q=camera_module_cache_ram_113__5
+ QB=#dummy[1588] D=nx16433 CLK=clk R=rst
Xix16434 mux21_ni $PINS Y=nx16433 A0=camera_module_cache_ram_113__5 A1=nx35450
+ S0=nx35036
Xcamera_module_cache_reg_ram_97__5 dffr $PINS Q=camera_module_cache_ram_97__5
+ QB=#dummy[1589] D=nx16443 CLK=clk R=rst
Xix16444 mux21_ni $PINS Y=nx16443 A0=camera_module_cache_ram_97__5 A1=nx35450
+ S0=nx35040
Xix19565 nand04 $PINS Y=nx19564 A0=nx31253 A1=nx31261 A2=nx31269 A3=nx31277
Xix31254 aoi22 $PINS Y=nx31253 A0=camera_module_cache_ram_129__5 A1=nx36156
+ B0=camera_module_cache_ram_145__5 B1=nx36196
Xcamera_module_cache_reg_ram_129__5 dffr $PINS Q=camera_module_cache_ram_129__5
+ QB=#dummy[1590] D=nx16423 CLK=clk R=rst
Xix16424 mux21_ni $PINS Y=nx16423 A0=camera_module_cache_ram_129__5 A1=nx35450
+ S0=nx35032
Xcamera_module_cache_reg_ram_145__5 dffr $PINS Q=camera_module_cache_ram_145__5
+ QB=#dummy[1591] D=nx16413 CLK=clk R=rst
Xix16414 mux21_ni $PINS Y=nx16413 A0=camera_module_cache_ram_145__5 A1=nx35450
+ S0=nx35028
Xix31262 aoi22 $PINS Y=nx31261 A0=camera_module_cache_ram_177__5 A1=nx36236
+ B0=camera_module_cache_ram_161__5 B1=nx36276
Xcamera_module_cache_reg_ram_177__5 dffr $PINS Q=camera_module_cache_ram_177__5
+ QB=#dummy[1592] D=nx16393 CLK=clk R=rst
Xix16394 mux21_ni $PINS Y=nx16393 A0=camera_module_cache_ram_177__5 A1=nx35450
+ S0=nx35020
Xcamera_module_cache_reg_ram_161__5 dffr $PINS Q=camera_module_cache_ram_161__5
+ QB=#dummy[1593] D=nx16403 CLK=clk R=rst
Xix16404 mux21_ni $PINS Y=nx16403 A0=camera_module_cache_ram_161__5 A1=nx35450
+ S0=nx35024
Xix31270 aoi22 $PINS Y=nx31269 A0=camera_module_cache_ram_193__5 A1=nx36316
+ B0=camera_module_cache_ram_209__5 B1=nx36356
Xcamera_module_cache_reg_ram_193__5 dffr $PINS Q=camera_module_cache_ram_193__5
+ QB=#dummy[1594] D=nx16383 CLK=clk R=rst
Xix16384 mux21_ni $PINS Y=nx16383 A0=camera_module_cache_ram_193__5 A1=nx35452
+ S0=nx35016
Xcamera_module_cache_reg_ram_209__5 dffr $PINS Q=camera_module_cache_ram_209__5
+ QB=#dummy[1595] D=nx16373 CLK=clk R=rst
Xix16374 mux21_ni $PINS Y=nx16373 A0=camera_module_cache_ram_209__5 A1=nx35452
+ S0=nx35012
Xix31278 aoi22 $PINS Y=nx31277 A0=camera_module_cache_ram_225__5 A1=nx36396
+ B0=camera_module_cache_ram_241__5 B1=nx36436
Xcamera_module_cache_reg_ram_225__5 dffr $PINS Q=camera_module_cache_ram_225__5
+ QB=#dummy[1596] D=nx16363 CLK=clk R=rst
Xix16364 mux21_ni $PINS Y=nx16363 A0=camera_module_cache_ram_225__5 A1=nx35452
+ S0=nx35008
Xcamera_module_cache_reg_ram_241__5 dffr $PINS Q=camera_module_cache_ram_241__5
+ QB=#dummy[1597] D=nx16353 CLK=clk R=rst
Xix16354 mux21_ni $PINS Y=nx16353 A0=camera_module_cache_ram_241__5 A1=nx35452
+ S0=nx35004
Xix31286 oai21 $PINS Y=nx31285 A0=nx19478 A1=nx19400 B0=nx36456
Xix19479 nand04 $PINS Y=nx19478 A0=nx31288 A1=nx31296 A2=nx31304 A3=nx31312
Xix31289 aoi22 $PINS Y=nx31288 A0=camera_module_cache_ram_2__5 A1=nx35836
+ B0=camera_module_cache_ram_18__5 B1=nx35876
Xcamera_module_cache_reg_ram_2__5 dffr $PINS Q=camera_module_cache_ram_2__5
+ QB=#dummy[1598] D=nx16343 CLK=clk R=rst
Xix16344 mux21_ni $PINS Y=nx16343 A0=camera_module_cache_ram_2__5 A1=nx35452
+ S0=nx34994
Xcamera_module_cache_reg_ram_18__5 dffr $PINS Q=camera_module_cache_ram_18__5
+ QB=#dummy[1599] D=nx16333 CLK=clk R=rst
Xix16334 mux21_ni $PINS Y=nx16333 A0=camera_module_cache_ram_18__5 A1=nx35452
+ S0=nx34990
Xix31297 aoi22 $PINS Y=nx31296 A0=camera_module_cache_ram_34__5 A1=nx35916
+ B0=camera_module_cache_ram_50__5 B1=nx35956
Xcamera_module_cache_reg_ram_34__5 dffr $PINS Q=camera_module_cache_ram_34__5
+ QB=#dummy[1600] D=nx16323 CLK=clk R=rst
Xix16324 mux21_ni $PINS Y=nx16323 A0=camera_module_cache_ram_34__5 A1=nx35452
+ S0=nx34986
Xcamera_module_cache_reg_ram_50__5 dffr $PINS Q=camera_module_cache_ram_50__5
+ QB=#dummy[1601] D=nx16313 CLK=clk R=rst
Xix16314 mux21_ni $PINS Y=nx16313 A0=camera_module_cache_ram_50__5 A1=nx35454
+ S0=nx34982
Xix31305 aoi22 $PINS Y=nx31304 A0=camera_module_cache_ram_66__5 A1=nx35996
+ B0=camera_module_cache_ram_82__5 B1=nx36036
Xcamera_module_cache_reg_ram_66__5 dffr $PINS Q=camera_module_cache_ram_66__5
+ QB=#dummy[1602] D=nx16303 CLK=clk R=rst
Xix16304 mux21_ni $PINS Y=nx16303 A0=camera_module_cache_ram_66__5 A1=nx35454
+ S0=nx34978
Xcamera_module_cache_reg_ram_82__5 dffr $PINS Q=camera_module_cache_ram_82__5
+ QB=#dummy[1603] D=nx16293 CLK=clk R=rst
Xix16294 mux21_ni $PINS Y=nx16293 A0=camera_module_cache_ram_82__5 A1=nx35454
+ S0=nx34974
Xix31313 aoi22 $PINS Y=nx31312 A0=camera_module_cache_ram_114__5 A1=nx36076
+ B0=camera_module_cache_ram_98__5 B1=nx36116
Xcamera_module_cache_reg_ram_114__5 dffr $PINS Q=camera_module_cache_ram_114__5
+ QB=#dummy[1604] D=nx16273 CLK=clk R=rst
Xix16274 mux21_ni $PINS Y=nx16273 A0=camera_module_cache_ram_114__5 A1=nx35454
+ S0=nx34966
Xcamera_module_cache_reg_ram_98__5 dffr $PINS Q=camera_module_cache_ram_98__5
+ QB=#dummy[1605] D=nx16283 CLK=clk R=rst
Xix16284 mux21_ni $PINS Y=nx16283 A0=camera_module_cache_ram_98__5 A1=nx35454
+ S0=nx34970
Xix19401 nand04 $PINS Y=nx19400 A0=nx31321 A1=nx31329 A2=nx31337 A3=nx31345
Xix31322 aoi22 $PINS Y=nx31321 A0=camera_module_cache_ram_130__5 A1=nx36156
+ B0=camera_module_cache_ram_146__5 B1=nx36196
Xcamera_module_cache_reg_ram_130__5 dffr $PINS Q=camera_module_cache_ram_130__5
+ QB=#dummy[1606] D=nx16263 CLK=clk R=rst
Xix16264 mux21_ni $PINS Y=nx16263 A0=camera_module_cache_ram_130__5 A1=nx35454
+ S0=nx34962
Xcamera_module_cache_reg_ram_146__5 dffr $PINS Q=camera_module_cache_ram_146__5
+ QB=#dummy[1607] D=nx16253 CLK=clk R=rst
Xix16254 mux21_ni $PINS Y=nx16253 A0=camera_module_cache_ram_146__5 A1=nx35454
+ S0=nx34958
Xix31330 aoi22 $PINS Y=nx31329 A0=camera_module_cache_ram_178__5 A1=nx36236
+ B0=camera_module_cache_ram_162__5 B1=nx36276
Xcamera_module_cache_reg_ram_178__5 dffr $PINS Q=camera_module_cache_ram_178__5
+ QB=#dummy[1608] D=nx16233 CLK=clk R=rst
Xix16234 mux21_ni $PINS Y=nx16233 A0=camera_module_cache_ram_178__5 A1=nx35456
+ S0=nx34950
Xcamera_module_cache_reg_ram_162__5 dffr $PINS Q=camera_module_cache_ram_162__5
+ QB=#dummy[1609] D=nx16243 CLK=clk R=rst
Xix16244 mux21_ni $PINS Y=nx16243 A0=camera_module_cache_ram_162__5 A1=nx35456
+ S0=nx34954
Xix31338 aoi22 $PINS Y=nx31337 A0=camera_module_cache_ram_194__5 A1=nx36316
+ B0=camera_module_cache_ram_210__5 B1=nx36356
Xcamera_module_cache_reg_ram_194__5 dffr $PINS Q=camera_module_cache_ram_194__5
+ QB=#dummy[1610] D=nx16223 CLK=clk R=rst
Xix16224 mux21_ni $PINS Y=nx16223 A0=camera_module_cache_ram_194__5 A1=nx35456
+ S0=nx34946
Xcamera_module_cache_reg_ram_210__5 dffr $PINS Q=camera_module_cache_ram_210__5
+ QB=#dummy[1611] D=nx16213 CLK=clk R=rst
Xix16214 mux21_ni $PINS Y=nx16213 A0=camera_module_cache_ram_210__5 A1=nx35456
+ S0=nx34942
Xix31346 aoi22 $PINS Y=nx31345 A0=camera_module_cache_ram_226__5 A1=nx36396
+ B0=camera_module_cache_ram_242__5 B1=nx36436
Xcamera_module_cache_reg_ram_226__5 dffr $PINS Q=camera_module_cache_ram_226__5
+ QB=#dummy[1612] D=nx16203 CLK=clk R=rst
Xix16204 mux21_ni $PINS Y=nx16203 A0=camera_module_cache_ram_226__5 A1=nx35456
+ S0=nx34938
Xcamera_module_cache_reg_ram_242__5 dffr $PINS Q=camera_module_cache_ram_242__5
+ QB=#dummy[1613] D=nx16193 CLK=clk R=rst
Xix16194 mux21_ni $PINS Y=nx16193 A0=camera_module_cache_ram_242__5 A1=nx35456
+ S0=nx34934
Xix31354 oai21 $PINS Y=nx31353 A0=nx19316 A1=nx19238 B0=nx36460
Xix19317 nand04 $PINS Y=nx19316 A0=nx31356 A1=nx31364 A2=nx31372 A3=nx31380
Xix31357 aoi22 $PINS Y=nx31356 A0=camera_module_cache_ram_3__5 A1=nx35836
+ B0=camera_module_cache_ram_19__5 B1=nx35876
Xcamera_module_cache_reg_ram_3__5 dffr $PINS Q=camera_module_cache_ram_3__5
+ QB=#dummy[1614] D=nx16183 CLK=clk R=rst
Xix16184 mux21_ni $PINS Y=nx16183 A0=camera_module_cache_ram_3__5 A1=nx35456
+ S0=nx34924
Xcamera_module_cache_reg_ram_19__5 dffr $PINS Q=camera_module_cache_ram_19__5
+ QB=#dummy[1615] D=nx16173 CLK=clk R=rst
Xix16174 mux21_ni $PINS Y=nx16173 A0=camera_module_cache_ram_19__5 A1=nx35458
+ S0=nx34920
Xix31365 aoi22 $PINS Y=nx31364 A0=camera_module_cache_ram_35__5 A1=nx35916
+ B0=camera_module_cache_ram_51__5 B1=nx35956
Xcamera_module_cache_reg_ram_35__5 dffr $PINS Q=camera_module_cache_ram_35__5
+ QB=#dummy[1616] D=nx16163 CLK=clk R=rst
Xix16164 mux21_ni $PINS Y=nx16163 A0=camera_module_cache_ram_35__5 A1=nx35458
+ S0=nx34916
Xcamera_module_cache_reg_ram_51__5 dffr $PINS Q=camera_module_cache_ram_51__5
+ QB=#dummy[1617] D=nx16153 CLK=clk R=rst
Xix16154 mux21_ni $PINS Y=nx16153 A0=camera_module_cache_ram_51__5 A1=nx35458
+ S0=nx34912
Xix31373 aoi22 $PINS Y=nx31372 A0=camera_module_cache_ram_67__5 A1=nx35996
+ B0=camera_module_cache_ram_83__5 B1=nx36036
Xcamera_module_cache_reg_ram_67__5 dffr $PINS Q=camera_module_cache_ram_67__5
+ QB=#dummy[1618] D=nx16143 CLK=clk R=rst
Xix16144 mux21_ni $PINS Y=nx16143 A0=camera_module_cache_ram_67__5 A1=nx35458
+ S0=nx34908
Xcamera_module_cache_reg_ram_83__5 dffr $PINS Q=camera_module_cache_ram_83__5
+ QB=#dummy[1619] D=nx16133 CLK=clk R=rst
Xix16134 mux21_ni $PINS Y=nx16133 A0=camera_module_cache_ram_83__5 A1=nx35458
+ S0=nx34904
Xix31381 aoi22 $PINS Y=nx31380 A0=camera_module_cache_ram_115__5 A1=nx36076
+ B0=camera_module_cache_ram_99__5 B1=nx36116
Xcamera_module_cache_reg_ram_115__5 dffr $PINS Q=camera_module_cache_ram_115__5
+ QB=#dummy[1620] D=nx16113 CLK=clk R=rst
Xix16114 mux21_ni $PINS Y=nx16113 A0=camera_module_cache_ram_115__5 A1=nx35458
+ S0=nx34896
Xcamera_module_cache_reg_ram_99__5 dffr $PINS Q=camera_module_cache_ram_99__5
+ QB=#dummy[1621] D=nx16123 CLK=clk R=rst
Xix16124 mux21_ni $PINS Y=nx16123 A0=camera_module_cache_ram_99__5 A1=nx35458
+ S0=nx34900
Xix19239 nand04 $PINS Y=nx19238 A0=nx31389 A1=nx31397 A2=nx31405 A3=nx31413
Xix31390 aoi22 $PINS Y=nx31389 A0=camera_module_cache_ram_131__5 A1=nx36156
+ B0=camera_module_cache_ram_147__5 B1=nx36196
Xcamera_module_cache_reg_ram_131__5 dffr $PINS Q=camera_module_cache_ram_131__5
+ QB=#dummy[1622] D=nx16103 CLK=clk R=rst
Xix16104 mux21_ni $PINS Y=nx16103 A0=camera_module_cache_ram_131__5 A1=nx35460
+ S0=nx34892
Xcamera_module_cache_reg_ram_147__5 dffr $PINS Q=camera_module_cache_ram_147__5
+ QB=#dummy[1623] D=nx16093 CLK=clk R=rst
Xix16094 mux21_ni $PINS Y=nx16093 A0=camera_module_cache_ram_147__5 A1=nx35460
+ S0=nx34888
Xix31398 aoi22 $PINS Y=nx31397 A0=camera_module_cache_ram_179__5 A1=nx36236
+ B0=camera_module_cache_ram_163__5 B1=nx36276
Xcamera_module_cache_reg_ram_179__5 dffr $PINS Q=camera_module_cache_ram_179__5
+ QB=#dummy[1624] D=nx16073 CLK=clk R=rst
Xix16074 mux21_ni $PINS Y=nx16073 A0=camera_module_cache_ram_179__5 A1=nx35460
+ S0=nx34880
Xcamera_module_cache_reg_ram_163__5 dffr $PINS Q=camera_module_cache_ram_163__5
+ QB=#dummy[1625] D=nx16083 CLK=clk R=rst
Xix16084 mux21_ni $PINS Y=nx16083 A0=camera_module_cache_ram_163__5 A1=nx35460
+ S0=nx34884
Xix31406 aoi22 $PINS Y=nx31405 A0=camera_module_cache_ram_195__5 A1=nx36316
+ B0=camera_module_cache_ram_211__5 B1=nx36356
Xcamera_module_cache_reg_ram_195__5 dffr $PINS Q=camera_module_cache_ram_195__5
+ QB=#dummy[1626] D=nx16063 CLK=clk R=rst
Xix16064 mux21_ni $PINS Y=nx16063 A0=camera_module_cache_ram_195__5 A1=nx35460
+ S0=nx34876
Xcamera_module_cache_reg_ram_211__5 dffr $PINS Q=camera_module_cache_ram_211__5
+ QB=#dummy[1627] D=nx16053 CLK=clk R=rst
Xix16054 mux21_ni $PINS Y=nx16053 A0=camera_module_cache_ram_211__5 A1=nx35460
+ S0=nx34872
Xix31414 aoi22 $PINS Y=nx31413 A0=camera_module_cache_ram_227__5 A1=nx36396
+ B0=camera_module_cache_ram_243__5 B1=nx36436
Xcamera_module_cache_reg_ram_227__5 dffr $PINS Q=camera_module_cache_ram_227__5
+ QB=#dummy[1628] D=nx16043 CLK=clk R=rst
Xix16044 mux21_ni $PINS Y=nx16043 A0=camera_module_cache_ram_227__5 A1=nx35460
+ S0=nx34868
Xcamera_module_cache_reg_ram_243__5 dffr $PINS Q=camera_module_cache_ram_243__5
+ QB=#dummy[1629] D=nx16033 CLK=clk R=rst
Xix16034 mux21_ni $PINS Y=nx16033 A0=camera_module_cache_ram_243__5 A1=nx35462
+ S0=nx34864
Xix19161 nand04 $PINS Y=nx19160 A0=nx31422 A1=nx31490 A2=nx31558 A3=nx31626
Xix31423 oai21 $PINS Y=nx31422 A0=nx19150 A1=nx19072 B0=nx36464
Xix19151 nand04 $PINS Y=nx19150 A0=nx31425 A1=nx31433 A2=nx31441 A3=nx31449
Xix31426 aoi22 $PINS Y=nx31425 A0=camera_module_cache_ram_4__5 A1=nx35836
+ B0=camera_module_cache_ram_20__5 B1=nx35876
Xcamera_module_cache_reg_ram_4__5 dffr $PINS Q=camera_module_cache_ram_4__5
+ QB=#dummy[1630] D=nx16023 CLK=clk R=rst
Xix16024 mux21_ni $PINS Y=nx16023 A0=camera_module_cache_ram_4__5 A1=nx35462
+ S0=nx34854
Xcamera_module_cache_reg_ram_20__5 dffr $PINS Q=camera_module_cache_ram_20__5
+ QB=#dummy[1631] D=nx16013 CLK=clk R=rst
Xix16014 mux21_ni $PINS Y=nx16013 A0=camera_module_cache_ram_20__5 A1=nx35462
+ S0=nx34850
Xix31434 aoi22 $PINS Y=nx31433 A0=camera_module_cache_ram_36__5 A1=nx35916
+ B0=camera_module_cache_ram_52__5 B1=nx35956
Xcamera_module_cache_reg_ram_36__5 dffr $PINS Q=camera_module_cache_ram_36__5
+ QB=#dummy[1632] D=nx16003 CLK=clk R=rst
Xix16004 mux21_ni $PINS Y=nx16003 A0=camera_module_cache_ram_36__5 A1=nx35462
+ S0=nx34846
Xcamera_module_cache_reg_ram_52__5 dffr $PINS Q=camera_module_cache_ram_52__5
+ QB=#dummy[1633] D=nx15993 CLK=clk R=rst
Xix15994 mux21_ni $PINS Y=nx15993 A0=camera_module_cache_ram_52__5 A1=nx35462
+ S0=nx34842
Xix31442 aoi22 $PINS Y=nx31441 A0=camera_module_cache_ram_68__5 A1=nx35996
+ B0=camera_module_cache_ram_84__5 B1=nx36036
Xcamera_module_cache_reg_ram_68__5 dffr $PINS Q=camera_module_cache_ram_68__5
+ QB=#dummy[1634] D=nx15983 CLK=clk R=rst
Xix15984 mux21_ni $PINS Y=nx15983 A0=camera_module_cache_ram_68__5 A1=nx35462
+ S0=nx34838
Xcamera_module_cache_reg_ram_84__5 dffr $PINS Q=camera_module_cache_ram_84__5
+ QB=#dummy[1635] D=nx15973 CLK=clk R=rst
Xix15974 mux21_ni $PINS Y=nx15973 A0=camera_module_cache_ram_84__5 A1=nx35462
+ S0=nx34834
Xix31450 aoi22 $PINS Y=nx31449 A0=camera_module_cache_ram_116__5 A1=nx36076
+ B0=camera_module_cache_ram_100__5 B1=nx36116
Xcamera_module_cache_reg_ram_116__5 dffr $PINS Q=camera_module_cache_ram_116__5
+ QB=#dummy[1636] D=nx15953 CLK=clk R=rst
Xix15954 mux21_ni $PINS Y=nx15953 A0=camera_module_cache_ram_116__5 A1=nx35464
+ S0=nx34826
Xcamera_module_cache_reg_ram_100__5 dffr $PINS Q=camera_module_cache_ram_100__5
+ QB=#dummy[1637] D=nx15963 CLK=clk R=rst
Xix15964 mux21_ni $PINS Y=nx15963 A0=camera_module_cache_ram_100__5 A1=nx35464
+ S0=nx34830
Xix19073 nand04 $PINS Y=nx19072 A0=nx31458 A1=nx31466 A2=nx31474 A3=nx31482
Xix31459 aoi22 $PINS Y=nx31458 A0=camera_module_cache_ram_132__5 A1=nx36156
+ B0=camera_module_cache_ram_148__5 B1=nx36196
Xcamera_module_cache_reg_ram_132__5 dffr $PINS Q=camera_module_cache_ram_132__5
+ QB=#dummy[1638] D=nx15943 CLK=clk R=rst
Xix15944 mux21_ni $PINS Y=nx15943 A0=camera_module_cache_ram_132__5 A1=nx35464
+ S0=nx34822
Xcamera_module_cache_reg_ram_148__5 dffr $PINS Q=camera_module_cache_ram_148__5
+ QB=#dummy[1639] D=nx15933 CLK=clk R=rst
Xix15934 mux21_ni $PINS Y=nx15933 A0=camera_module_cache_ram_148__5 A1=nx35464
+ S0=nx34818
Xix31467 aoi22 $PINS Y=nx31466 A0=camera_module_cache_ram_180__5 A1=nx36236
+ B0=camera_module_cache_ram_164__5 B1=nx36276
Xcamera_module_cache_reg_ram_180__5 dffr $PINS Q=camera_module_cache_ram_180__5
+ QB=#dummy[1640] D=nx15913 CLK=clk R=rst
Xix15914 mux21_ni $PINS Y=nx15913 A0=camera_module_cache_ram_180__5 A1=nx35464
+ S0=nx34810
Xcamera_module_cache_reg_ram_164__5 dffr $PINS Q=camera_module_cache_ram_164__5
+ QB=#dummy[1641] D=nx15923 CLK=clk R=rst
Xix15924 mux21_ni $PINS Y=nx15923 A0=camera_module_cache_ram_164__5 A1=nx35464
+ S0=nx34814
Xix31475 aoi22 $PINS Y=nx31474 A0=camera_module_cache_ram_196__5 A1=nx36316
+ B0=camera_module_cache_ram_212__5 B1=nx36356
Xcamera_module_cache_reg_ram_196__5 dffr $PINS Q=camera_module_cache_ram_196__5
+ QB=#dummy[1642] D=nx15903 CLK=clk R=rst
Xix15904 mux21_ni $PINS Y=nx15903 A0=camera_module_cache_ram_196__5 A1=nx35464
+ S0=nx34806
Xcamera_module_cache_reg_ram_212__5 dffr $PINS Q=camera_module_cache_ram_212__5
+ QB=#dummy[1643] D=nx15893 CLK=clk R=rst
Xix15894 mux21_ni $PINS Y=nx15893 A0=camera_module_cache_ram_212__5 A1=nx35466
+ S0=nx34802
Xix31483 aoi22 $PINS Y=nx31482 A0=camera_module_cache_ram_228__5 A1=nx36396
+ B0=camera_module_cache_ram_244__5 B1=nx36436
Xcamera_module_cache_reg_ram_228__5 dffr $PINS Q=camera_module_cache_ram_228__5
+ QB=#dummy[1644] D=nx15883 CLK=clk R=rst
Xix15884 mux21_ni $PINS Y=nx15883 A0=camera_module_cache_ram_228__5 A1=nx35466
+ S0=nx34798
Xcamera_module_cache_reg_ram_244__5 dffr $PINS Q=camera_module_cache_ram_244__5
+ QB=#dummy[1645] D=nx15873 CLK=clk R=rst
Xix15874 mux21_ni $PINS Y=nx15873 A0=camera_module_cache_ram_244__5 A1=nx35466
+ S0=nx34794
Xix31491 oai21 $PINS Y=nx31490 A0=nx18988 A1=nx18910 B0=nx36468
Xix18989 nand04 $PINS Y=nx18988 A0=nx31493 A1=nx31501 A2=nx31509 A3=nx31517
Xix31494 aoi22 $PINS Y=nx31493 A0=camera_module_cache_ram_5__5 A1=nx35838
+ B0=camera_module_cache_ram_21__5 B1=nx35878
Xcamera_module_cache_reg_ram_5__5 dffr $PINS Q=camera_module_cache_ram_5__5
+ QB=#dummy[1646] D=nx15863 CLK=clk R=rst
Xix15864 mux21_ni $PINS Y=nx15863 A0=camera_module_cache_ram_5__5 A1=nx35466
+ S0=nx34784
Xcamera_module_cache_reg_ram_21__5 dffr $PINS Q=camera_module_cache_ram_21__5
+ QB=#dummy[1647] D=nx15853 CLK=clk R=rst
Xix15854 mux21_ni $PINS Y=nx15853 A0=camera_module_cache_ram_21__5 A1=nx35466
+ S0=nx34780
Xix31502 aoi22 $PINS Y=nx31501 A0=camera_module_cache_ram_37__5 A1=nx35918
+ B0=camera_module_cache_ram_53__5 B1=nx35958
Xcamera_module_cache_reg_ram_37__5 dffr $PINS Q=camera_module_cache_ram_37__5
+ QB=#dummy[1648] D=nx15843 CLK=clk R=rst
Xix15844 mux21_ni $PINS Y=nx15843 A0=camera_module_cache_ram_37__5 A1=nx35466
+ S0=nx34776
Xcamera_module_cache_reg_ram_53__5 dffr $PINS Q=camera_module_cache_ram_53__5
+ QB=#dummy[1649] D=nx15833 CLK=clk R=rst
Xix15834 mux21_ni $PINS Y=nx15833 A0=camera_module_cache_ram_53__5 A1=nx35466
+ S0=nx34772
Xix31510 aoi22 $PINS Y=nx31509 A0=camera_module_cache_ram_69__5 A1=nx35998
+ B0=camera_module_cache_ram_85__5 B1=nx36038
Xcamera_module_cache_reg_ram_69__5 dffr $PINS Q=camera_module_cache_ram_69__5
+ QB=#dummy[1650] D=nx15823 CLK=clk R=rst
Xix15824 mux21_ni $PINS Y=nx15823 A0=camera_module_cache_ram_69__5 A1=nx35468
+ S0=nx34768
Xcamera_module_cache_reg_ram_85__5 dffr $PINS Q=camera_module_cache_ram_85__5
+ QB=#dummy[1651] D=nx15813 CLK=clk R=rst
Xix15814 mux21_ni $PINS Y=nx15813 A0=camera_module_cache_ram_85__5 A1=nx35468
+ S0=nx34764
Xix31518 aoi22 $PINS Y=nx31517 A0=camera_module_cache_ram_117__5 A1=nx36078
+ B0=camera_module_cache_ram_101__5 B1=nx36118
Xcamera_module_cache_reg_ram_117__5 dffr $PINS Q=camera_module_cache_ram_117__5
+ QB=#dummy[1652] D=nx15793 CLK=clk R=rst
Xix15794 mux21_ni $PINS Y=nx15793 A0=camera_module_cache_ram_117__5 A1=nx35468
+ S0=nx34756
Xcamera_module_cache_reg_ram_101__5 dffr $PINS Q=camera_module_cache_ram_101__5
+ QB=#dummy[1653] D=nx15803 CLK=clk R=rst
Xix15804 mux21_ni $PINS Y=nx15803 A0=camera_module_cache_ram_101__5 A1=nx35468
+ S0=nx34760
Xix18911 nand04 $PINS Y=nx18910 A0=nx31526 A1=nx31534 A2=nx31542 A3=nx31550
Xix31527 aoi22 $PINS Y=nx31526 A0=camera_module_cache_ram_133__5 A1=nx36158
+ B0=camera_module_cache_ram_149__5 B1=nx36198
Xcamera_module_cache_reg_ram_133__5 dffr $PINS Q=camera_module_cache_ram_133__5
+ QB=#dummy[1654] D=nx15783 CLK=clk R=rst
Xix15784 mux21_ni $PINS Y=nx15783 A0=camera_module_cache_ram_133__5 A1=nx35468
+ S0=nx34752
Xcamera_module_cache_reg_ram_149__5 dffr $PINS Q=camera_module_cache_ram_149__5
+ QB=#dummy[1655] D=nx15773 CLK=clk R=rst
Xix15774 mux21_ni $PINS Y=nx15773 A0=camera_module_cache_ram_149__5 A1=nx35468
+ S0=nx34748
Xix31535 aoi22 $PINS Y=nx31534 A0=camera_module_cache_ram_181__5 A1=nx36238
+ B0=camera_module_cache_ram_165__5 B1=nx36278
Xcamera_module_cache_reg_ram_181__5 dffr $PINS Q=camera_module_cache_ram_181__5
+ QB=#dummy[1656] D=nx15753 CLK=clk R=rst
Xix15754 mux21_ni $PINS Y=nx15753 A0=camera_module_cache_ram_181__5 A1=nx35468
+ S0=nx34740
Xcamera_module_cache_reg_ram_165__5 dffr $PINS Q=camera_module_cache_ram_165__5
+ QB=#dummy[1657] D=nx15763 CLK=clk R=rst
Xix15764 mux21_ni $PINS Y=nx15763 A0=camera_module_cache_ram_165__5 A1=nx35470
+ S0=nx34744
Xix31543 aoi22 $PINS Y=nx31542 A0=camera_module_cache_ram_197__5 A1=nx36318
+ B0=camera_module_cache_ram_213__5 B1=nx36358
Xcamera_module_cache_reg_ram_197__5 dffr $PINS Q=camera_module_cache_ram_197__5
+ QB=#dummy[1658] D=nx15743 CLK=clk R=rst
Xix15744 mux21_ni $PINS Y=nx15743 A0=camera_module_cache_ram_197__5 A1=nx35470
+ S0=nx34736
Xcamera_module_cache_reg_ram_213__5 dffr $PINS Q=camera_module_cache_ram_213__5
+ QB=#dummy[1659] D=nx15733 CLK=clk R=rst
Xix15734 mux21_ni $PINS Y=nx15733 A0=camera_module_cache_ram_213__5 A1=nx35470
+ S0=nx34732
Xix31551 aoi22 $PINS Y=nx31550 A0=camera_module_cache_ram_229__5 A1=nx36398
+ B0=camera_module_cache_ram_245__5 B1=nx36438
Xcamera_module_cache_reg_ram_229__5 dffr $PINS Q=camera_module_cache_ram_229__5
+ QB=#dummy[1660] D=nx15723 CLK=clk R=rst
Xix15724 mux21_ni $PINS Y=nx15723 A0=camera_module_cache_ram_229__5 A1=nx35470
+ S0=nx34728
Xcamera_module_cache_reg_ram_245__5 dffr $PINS Q=camera_module_cache_ram_245__5
+ QB=#dummy[1661] D=nx15713 CLK=clk R=rst
Xix15714 mux21_ni $PINS Y=nx15713 A0=camera_module_cache_ram_245__5 A1=nx35470
+ S0=nx34724
Xix31559 oai21 $PINS Y=nx31558 A0=nx18824 A1=nx18746 B0=nx36472
Xix18825 nand04 $PINS Y=nx18824 A0=nx31561 A1=nx31569 A2=nx31577 A3=nx31585
Xix31562 aoi22 $PINS Y=nx31561 A0=camera_module_cache_ram_6__5 A1=nx35838
+ B0=camera_module_cache_ram_22__5 B1=nx35878
Xcamera_module_cache_reg_ram_6__5 dffr $PINS Q=camera_module_cache_ram_6__5
+ QB=#dummy[1662] D=nx15703 CLK=clk R=rst
Xix15704 mux21_ni $PINS Y=nx15703 A0=camera_module_cache_ram_6__5 A1=nx35470
+ S0=nx34714
Xcamera_module_cache_reg_ram_22__5 dffr $PINS Q=camera_module_cache_ram_22__5
+ QB=#dummy[1663] D=nx15693 CLK=clk R=rst
Xix15694 mux21_ni $PINS Y=nx15693 A0=camera_module_cache_ram_22__5 A1=nx35470
+ S0=nx34710
Xix31570 aoi22 $PINS Y=nx31569 A0=camera_module_cache_ram_38__5 A1=nx35918
+ B0=camera_module_cache_ram_54__5 B1=nx35958
Xcamera_module_cache_reg_ram_38__5 dffr $PINS Q=camera_module_cache_ram_38__5
+ QB=#dummy[1664] D=nx15683 CLK=clk R=rst
Xix15684 mux21_ni $PINS Y=nx15683 A0=camera_module_cache_ram_38__5 A1=nx35472
+ S0=nx34706
Xcamera_module_cache_reg_ram_54__5 dffr $PINS Q=camera_module_cache_ram_54__5
+ QB=#dummy[1665] D=nx15673 CLK=clk R=rst
Xix15674 mux21_ni $PINS Y=nx15673 A0=camera_module_cache_ram_54__5 A1=nx35472
+ S0=nx34702
Xix31578 aoi22 $PINS Y=nx31577 A0=camera_module_cache_ram_70__5 A1=nx35998
+ B0=camera_module_cache_ram_86__5 B1=nx36038
Xcamera_module_cache_reg_ram_70__5 dffr $PINS Q=camera_module_cache_ram_70__5
+ QB=#dummy[1666] D=nx15663 CLK=clk R=rst
Xix15664 mux21_ni $PINS Y=nx15663 A0=camera_module_cache_ram_70__5 A1=nx35472
+ S0=nx34698
Xcamera_module_cache_reg_ram_86__5 dffr $PINS Q=camera_module_cache_ram_86__5
+ QB=#dummy[1667] D=nx15653 CLK=clk R=rst
Xix15654 mux21_ni $PINS Y=nx15653 A0=camera_module_cache_ram_86__5 A1=nx35472
+ S0=nx34694
Xix31586 aoi22 $PINS Y=nx31585 A0=camera_module_cache_ram_118__5 A1=nx36078
+ B0=camera_module_cache_ram_102__5 B1=nx36118
Xcamera_module_cache_reg_ram_118__5 dffr $PINS Q=camera_module_cache_ram_118__5
+ QB=#dummy[1668] D=nx15633 CLK=clk R=rst
Xix15634 mux21_ni $PINS Y=nx15633 A0=camera_module_cache_ram_118__5 A1=nx35472
+ S0=nx34686
Xcamera_module_cache_reg_ram_102__5 dffr $PINS Q=camera_module_cache_ram_102__5
+ QB=#dummy[1669] D=nx15643 CLK=clk R=rst
Xix15644 mux21_ni $PINS Y=nx15643 A0=camera_module_cache_ram_102__5 A1=nx35472
+ S0=nx34690
Xix18747 nand04 $PINS Y=nx18746 A0=nx31594 A1=nx31602 A2=nx31610 A3=nx31618
Xix31595 aoi22 $PINS Y=nx31594 A0=camera_module_cache_ram_134__5 A1=nx36158
+ B0=camera_module_cache_ram_150__5 B1=nx36198
Xcamera_module_cache_reg_ram_134__5 dffr $PINS Q=camera_module_cache_ram_134__5
+ QB=#dummy[1670] D=nx15623 CLK=clk R=rst
Xix15624 mux21_ni $PINS Y=nx15623 A0=camera_module_cache_ram_134__5 A1=nx35472
+ S0=nx34682
Xcamera_module_cache_reg_ram_150__5 dffr $PINS Q=camera_module_cache_ram_150__5
+ QB=#dummy[1671] D=nx15613 CLK=clk R=rst
Xix15614 mux21_ni $PINS Y=nx15613 A0=camera_module_cache_ram_150__5 A1=nx35474
+ S0=nx34678
Xix31603 aoi22 $PINS Y=nx31602 A0=camera_module_cache_ram_182__5 A1=nx36238
+ B0=camera_module_cache_ram_166__5 B1=nx36278
Xcamera_module_cache_reg_ram_182__5 dffr $PINS Q=camera_module_cache_ram_182__5
+ QB=#dummy[1672] D=nx15593 CLK=clk R=rst
Xix15594 mux21_ni $PINS Y=nx15593 A0=camera_module_cache_ram_182__5 A1=nx35474
+ S0=nx34670
Xcamera_module_cache_reg_ram_166__5 dffr $PINS Q=camera_module_cache_ram_166__5
+ QB=#dummy[1673] D=nx15603 CLK=clk R=rst
Xix15604 mux21_ni $PINS Y=nx15603 A0=camera_module_cache_ram_166__5 A1=nx35474
+ S0=nx34674
Xix31611 aoi22 $PINS Y=nx31610 A0=camera_module_cache_ram_198__5 A1=nx36318
+ B0=camera_module_cache_ram_214__5 B1=nx36358
Xcamera_module_cache_reg_ram_198__5 dffr $PINS Q=camera_module_cache_ram_198__5
+ QB=#dummy[1674] D=nx15583 CLK=clk R=rst
Xix15584 mux21_ni $PINS Y=nx15583 A0=camera_module_cache_ram_198__5 A1=nx35474
+ S0=nx34666
Xcamera_module_cache_reg_ram_214__5 dffr $PINS Q=camera_module_cache_ram_214__5
+ QB=#dummy[1675] D=nx15573 CLK=clk R=rst
Xix15574 mux21_ni $PINS Y=nx15573 A0=camera_module_cache_ram_214__5 A1=nx35474
+ S0=nx34662
Xix31619 aoi22 $PINS Y=nx31618 A0=camera_module_cache_ram_230__5 A1=nx36398
+ B0=camera_module_cache_ram_246__5 B1=nx36438
Xcamera_module_cache_reg_ram_230__5 dffr $PINS Q=camera_module_cache_ram_230__5
+ QB=#dummy[1676] D=nx15563 CLK=clk R=rst
Xix15564 mux21_ni $PINS Y=nx15563 A0=camera_module_cache_ram_230__5 A1=nx35474
+ S0=nx34658
Xcamera_module_cache_reg_ram_246__5 dffr $PINS Q=camera_module_cache_ram_246__5
+ QB=#dummy[1677] D=nx15553 CLK=clk R=rst
Xix15554 mux21_ni $PINS Y=nx15553 A0=camera_module_cache_ram_246__5 A1=nx35474
+ S0=nx34654
Xix31627 oai21 $PINS Y=nx31626 A0=nx18662 A1=nx18584 B0=nx36476
Xix18663 nand04 $PINS Y=nx18662 A0=nx31629 A1=nx31637 A2=nx31645 A3=nx31653
Xix31630 aoi22 $PINS Y=nx31629 A0=camera_module_cache_ram_7__5 A1=nx35838
+ B0=camera_module_cache_ram_23__5 B1=nx35878
Xcamera_module_cache_reg_ram_7__5 dffr $PINS Q=camera_module_cache_ram_7__5
+ QB=#dummy[1678] D=nx15543 CLK=clk R=rst
Xix15544 mux21_ni $PINS Y=nx15543 A0=camera_module_cache_ram_7__5 A1=nx35476
+ S0=nx34644
Xcamera_module_cache_reg_ram_23__5 dffr $PINS Q=camera_module_cache_ram_23__5
+ QB=#dummy[1679] D=nx15533 CLK=clk R=rst
Xix15534 mux21_ni $PINS Y=nx15533 A0=camera_module_cache_ram_23__5 A1=nx35476
+ S0=nx34640
Xix31638 aoi22 $PINS Y=nx31637 A0=camera_module_cache_ram_39__5 A1=nx35918
+ B0=camera_module_cache_ram_55__5 B1=nx35958
Xcamera_module_cache_reg_ram_39__5 dffr $PINS Q=camera_module_cache_ram_39__5
+ QB=#dummy[1680] D=nx15523 CLK=clk R=rst
Xix15524 mux21_ni $PINS Y=nx15523 A0=camera_module_cache_ram_39__5 A1=nx35476
+ S0=nx34636
Xcamera_module_cache_reg_ram_55__5 dffr $PINS Q=camera_module_cache_ram_55__5
+ QB=#dummy[1681] D=nx15513 CLK=clk R=rst
Xix15514 mux21_ni $PINS Y=nx15513 A0=camera_module_cache_ram_55__5 A1=nx35476
+ S0=nx34632
Xix31646 aoi22 $PINS Y=nx31645 A0=camera_module_cache_ram_71__5 A1=nx35998
+ B0=camera_module_cache_ram_87__5 B1=nx36038
Xcamera_module_cache_reg_ram_71__5 dffr $PINS Q=camera_module_cache_ram_71__5
+ QB=#dummy[1682] D=nx15503 CLK=clk R=rst
Xix15504 mux21_ni $PINS Y=nx15503 A0=camera_module_cache_ram_71__5 A1=nx35476
+ S0=nx34628
Xcamera_module_cache_reg_ram_87__5 dffr $PINS Q=camera_module_cache_ram_87__5
+ QB=#dummy[1683] D=nx15493 CLK=clk R=rst
Xix15494 mux21_ni $PINS Y=nx15493 A0=camera_module_cache_ram_87__5 A1=nx35476
+ S0=nx34624
Xix31654 aoi22 $PINS Y=nx31653 A0=camera_module_cache_ram_119__5 A1=nx36078
+ B0=camera_module_cache_ram_103__5 B1=nx36118
Xcamera_module_cache_reg_ram_119__5 dffr $PINS Q=camera_module_cache_ram_119__5
+ QB=#dummy[1684] D=nx15473 CLK=clk R=rst
Xix15474 mux21_ni $PINS Y=nx15473 A0=camera_module_cache_ram_119__5 A1=nx35476
+ S0=nx34616
Xcamera_module_cache_reg_ram_103__5 dffr $PINS Q=camera_module_cache_ram_103__5
+ QB=#dummy[1685] D=nx15483 CLK=clk R=rst
Xix15484 mux21_ni $PINS Y=nx15483 A0=camera_module_cache_ram_103__5 A1=nx35478
+ S0=nx34620
Xix18585 nand04 $PINS Y=nx18584 A0=nx31662 A1=nx31670 A2=nx31678 A3=nx31686
Xix31663 aoi22 $PINS Y=nx31662 A0=camera_module_cache_ram_135__5 A1=nx36158
+ B0=camera_module_cache_ram_151__5 B1=nx36198
Xcamera_module_cache_reg_ram_135__5 dffr $PINS Q=camera_module_cache_ram_135__5
+ QB=#dummy[1686] D=nx15463 CLK=clk R=rst
Xix15464 mux21_ni $PINS Y=nx15463 A0=camera_module_cache_ram_135__5 A1=nx35478
+ S0=nx34612
Xcamera_module_cache_reg_ram_151__5 dffr $PINS Q=camera_module_cache_ram_151__5
+ QB=#dummy[1687] D=nx15453 CLK=clk R=rst
Xix15454 mux21_ni $PINS Y=nx15453 A0=camera_module_cache_ram_151__5 A1=nx35478
+ S0=nx34608
Xix31671 aoi22 $PINS Y=nx31670 A0=camera_module_cache_ram_183__5 A1=nx36238
+ B0=camera_module_cache_ram_167__5 B1=nx36278
Xcamera_module_cache_reg_ram_183__5 dffr $PINS Q=camera_module_cache_ram_183__5
+ QB=#dummy[1688] D=nx15433 CLK=clk R=rst
Xix15434 mux21_ni $PINS Y=nx15433 A0=camera_module_cache_ram_183__5 A1=nx35478
+ S0=nx34600
Xcamera_module_cache_reg_ram_167__5 dffr $PINS Q=camera_module_cache_ram_167__5
+ QB=#dummy[1689] D=nx15443 CLK=clk R=rst
Xix15444 mux21_ni $PINS Y=nx15443 A0=camera_module_cache_ram_167__5 A1=nx35478
+ S0=nx34604
Xix31679 aoi22 $PINS Y=nx31678 A0=camera_module_cache_ram_199__5 A1=nx36318
+ B0=camera_module_cache_ram_215__5 B1=nx36358
Xcamera_module_cache_reg_ram_199__5 dffr $PINS Q=camera_module_cache_ram_199__5
+ QB=#dummy[1690] D=nx15423 CLK=clk R=rst
Xix15424 mux21_ni $PINS Y=nx15423 A0=camera_module_cache_ram_199__5 A1=nx35478
+ S0=nx34596
Xcamera_module_cache_reg_ram_215__5 dffr $PINS Q=camera_module_cache_ram_215__5
+ QB=#dummy[1691] D=nx15413 CLK=clk R=rst
Xix15414 mux21_ni $PINS Y=nx15413 A0=camera_module_cache_ram_215__5 A1=nx35478
+ S0=nx34592
Xix31687 aoi22 $PINS Y=nx31686 A0=camera_module_cache_ram_231__5 A1=nx36398
+ B0=camera_module_cache_ram_247__5 B1=nx36438
Xcamera_module_cache_reg_ram_231__5 dffr $PINS Q=camera_module_cache_ram_231__5
+ QB=#dummy[1692] D=nx15403 CLK=clk R=rst
Xix15404 mux21_ni $PINS Y=nx15403 A0=camera_module_cache_ram_231__5 A1=nx35480
+ S0=nx34588
Xcamera_module_cache_reg_ram_247__5 dffr $PINS Q=camera_module_cache_ram_247__5
+ QB=#dummy[1693] D=nx15393 CLK=clk R=rst
Xix15394 mux21_ni $PINS Y=nx15393 A0=camera_module_cache_ram_247__5 A1=nx35480
+ S0=nx34584
Xix18505 nand04 $PINS Y=nx18504 A0=nx31695 A1=nx31763 A2=nx31831 A3=nx31899
Xix31696 oai21 $PINS Y=nx31695 A0=nx18494 A1=nx18416 B0=nx36480
Xix18495 nand04 $PINS Y=nx18494 A0=nx31698 A1=nx31706 A2=nx31714 A3=nx31722
Xix31699 aoi22 $PINS Y=nx31698 A0=camera_module_cache_ram_8__5 A1=nx35838
+ B0=camera_module_cache_ram_24__5 B1=nx35878
Xcamera_module_cache_reg_ram_8__5 dffr $PINS Q=camera_module_cache_ram_8__5
+ QB=#dummy[1694] D=nx15383 CLK=clk R=rst
Xix15384 mux21_ni $PINS Y=nx15383 A0=camera_module_cache_ram_8__5 A1=nx35480
+ S0=nx34574
Xcamera_module_cache_reg_ram_24__5 dffr $PINS Q=camera_module_cache_ram_24__5
+ QB=#dummy[1695] D=nx15373 CLK=clk R=rst
Xix15374 mux21_ni $PINS Y=nx15373 A0=camera_module_cache_ram_24__5 A1=nx35480
+ S0=nx34570
Xix31707 aoi22 $PINS Y=nx31706 A0=camera_module_cache_ram_40__5 A1=nx35918
+ B0=camera_module_cache_ram_56__5 B1=nx35958
Xcamera_module_cache_reg_ram_40__5 dffr $PINS Q=camera_module_cache_ram_40__5
+ QB=#dummy[1696] D=nx15363 CLK=clk R=rst
Xix15364 mux21_ni $PINS Y=nx15363 A0=camera_module_cache_ram_40__5 A1=nx35480
+ S0=nx34566
Xcamera_module_cache_reg_ram_56__5 dffr $PINS Q=camera_module_cache_ram_56__5
+ QB=#dummy[1697] D=nx15353 CLK=clk R=rst
Xix15354 mux21_ni $PINS Y=nx15353 A0=camera_module_cache_ram_56__5 A1=nx35480
+ S0=nx34562
Xix31715 aoi22 $PINS Y=nx31714 A0=camera_module_cache_ram_72__5 A1=nx35998
+ B0=camera_module_cache_ram_88__5 B1=nx36038
Xcamera_module_cache_reg_ram_72__5 dffr $PINS Q=camera_module_cache_ram_72__5
+ QB=#dummy[1698] D=nx15343 CLK=clk R=rst
Xix15344 mux21_ni $PINS Y=nx15343 A0=camera_module_cache_ram_72__5 A1=nx35480
+ S0=nx34558
Xcamera_module_cache_reg_ram_88__5 dffr $PINS Q=camera_module_cache_ram_88__5
+ QB=#dummy[1699] D=nx15333 CLK=clk R=rst
Xix15334 mux21_ni $PINS Y=nx15333 A0=camera_module_cache_ram_88__5 A1=nx35482
+ S0=nx34554
Xix31723 aoi22 $PINS Y=nx31722 A0=camera_module_cache_ram_120__5 A1=nx36078
+ B0=camera_module_cache_ram_104__5 B1=nx36118
Xcamera_module_cache_reg_ram_120__5 dffr $PINS Q=camera_module_cache_ram_120__5
+ QB=#dummy[1700] D=nx15313 CLK=clk R=rst
Xix15314 mux21_ni $PINS Y=nx15313 A0=camera_module_cache_ram_120__5 A1=nx35482
+ S0=nx34546
Xcamera_module_cache_reg_ram_104__5 dffr $PINS Q=camera_module_cache_ram_104__5
+ QB=#dummy[1701] D=nx15323 CLK=clk R=rst
Xix15324 mux21_ni $PINS Y=nx15323 A0=camera_module_cache_ram_104__5 A1=nx35482
+ S0=nx34550
Xix18417 nand04 $PINS Y=nx18416 A0=nx31731 A1=nx31739 A2=nx31747 A3=nx31755
Xix31732 aoi22 $PINS Y=nx31731 A0=camera_module_cache_ram_136__5 A1=nx36158
+ B0=camera_module_cache_ram_152__5 B1=nx36198
Xcamera_module_cache_reg_ram_136__5 dffr $PINS Q=camera_module_cache_ram_136__5
+ QB=#dummy[1702] D=nx15303 CLK=clk R=rst
Xix15304 mux21_ni $PINS Y=nx15303 A0=camera_module_cache_ram_136__5 A1=nx35482
+ S0=nx34542
Xcamera_module_cache_reg_ram_152__5 dffr $PINS Q=camera_module_cache_ram_152__5
+ QB=#dummy[1703] D=nx15293 CLK=clk R=rst
Xix15294 mux21_ni $PINS Y=nx15293 A0=camera_module_cache_ram_152__5 A1=nx35482
+ S0=nx34538
Xix31740 aoi22 $PINS Y=nx31739 A0=camera_module_cache_ram_184__5 A1=nx36238
+ B0=camera_module_cache_ram_168__5 B1=nx36278
Xcamera_module_cache_reg_ram_184__5 dffr $PINS Q=camera_module_cache_ram_184__5
+ QB=#dummy[1704] D=nx15273 CLK=clk R=rst
Xix15274 mux21_ni $PINS Y=nx15273 A0=camera_module_cache_ram_184__5 A1=nx35482
+ S0=nx34530
Xcamera_module_cache_reg_ram_168__5 dffr $PINS Q=camera_module_cache_ram_168__5
+ QB=#dummy[1705] D=nx15283 CLK=clk R=rst
Xix15284 mux21_ni $PINS Y=nx15283 A0=camera_module_cache_ram_168__5 A1=nx35482
+ S0=nx34534
Xix31748 aoi22 $PINS Y=nx31747 A0=camera_module_cache_ram_200__5 A1=nx36318
+ B0=camera_module_cache_ram_216__5 B1=nx36358
Xcamera_module_cache_reg_ram_200__5 dffr $PINS Q=camera_module_cache_ram_200__5
+ QB=#dummy[1706] D=nx15263 CLK=clk R=rst
Xix15264 mux21_ni $PINS Y=nx15263 A0=camera_module_cache_ram_200__5 A1=nx35484
+ S0=nx34526
Xcamera_module_cache_reg_ram_216__5 dffr $PINS Q=camera_module_cache_ram_216__5
+ QB=#dummy[1707] D=nx15253 CLK=clk R=rst
Xix15254 mux21_ni $PINS Y=nx15253 A0=camera_module_cache_ram_216__5 A1=nx35484
+ S0=nx34522
Xix31756 aoi22 $PINS Y=nx31755 A0=camera_module_cache_ram_232__5 A1=nx36398
+ B0=camera_module_cache_ram_248__5 B1=nx36438
Xcamera_module_cache_reg_ram_232__5 dffr $PINS Q=camera_module_cache_ram_232__5
+ QB=#dummy[1708] D=nx15243 CLK=clk R=rst
Xix15244 mux21_ni $PINS Y=nx15243 A0=camera_module_cache_ram_232__5 A1=nx35484
+ S0=nx34518
Xcamera_module_cache_reg_ram_248__5 dffr $PINS Q=camera_module_cache_ram_248__5
+ QB=#dummy[1709] D=nx15233 CLK=clk R=rst
Xix15234 mux21_ni $PINS Y=nx15233 A0=camera_module_cache_ram_248__5 A1=nx35484
+ S0=nx34514
Xix31764 oai21 $PINS Y=nx31763 A0=nx18332 A1=nx18254 B0=nx36484
Xix18333 nand04 $PINS Y=nx18332 A0=nx31766 A1=nx31774 A2=nx31782 A3=nx31790
Xix31767 aoi22 $PINS Y=nx31766 A0=camera_module_cache_ram_9__5 A1=nx35838
+ B0=camera_module_cache_ram_25__5 B1=nx35878
Xcamera_module_cache_reg_ram_9__5 dffr $PINS Q=camera_module_cache_ram_9__5
+ QB=#dummy[1710] D=nx15223 CLK=clk R=rst
Xix15224 mux21_ni $PINS Y=nx15223 A0=camera_module_cache_ram_9__5 A1=nx35484
+ S0=nx34504
Xcamera_module_cache_reg_ram_25__5 dffr $PINS Q=camera_module_cache_ram_25__5
+ QB=#dummy[1711] D=nx15213 CLK=clk R=rst
Xix15214 mux21_ni $PINS Y=nx15213 A0=camera_module_cache_ram_25__5 A1=nx35484
+ S0=nx34500
Xix31775 aoi22 $PINS Y=nx31774 A0=camera_module_cache_ram_41__5 A1=nx35918
+ B0=camera_module_cache_ram_57__5 B1=nx35958
Xcamera_module_cache_reg_ram_41__5 dffr $PINS Q=camera_module_cache_ram_41__5
+ QB=#dummy[1712] D=nx15203 CLK=clk R=rst
Xix15204 mux21_ni $PINS Y=nx15203 A0=camera_module_cache_ram_41__5 A1=nx35484
+ S0=nx34496
Xcamera_module_cache_reg_ram_57__5 dffr $PINS Q=camera_module_cache_ram_57__5
+ QB=#dummy[1713] D=nx15193 CLK=clk R=rst
Xix15194 mux21_ni $PINS Y=nx15193 A0=camera_module_cache_ram_57__5 A1=nx35486
+ S0=nx34492
Xix31783 aoi22 $PINS Y=nx31782 A0=camera_module_cache_ram_73__5 A1=nx35998
+ B0=camera_module_cache_ram_89__5 B1=nx36038
Xcamera_module_cache_reg_ram_73__5 dffr $PINS Q=camera_module_cache_ram_73__5
+ QB=#dummy[1714] D=nx15183 CLK=clk R=rst
Xix15184 mux21_ni $PINS Y=nx15183 A0=camera_module_cache_ram_73__5 A1=nx35486
+ S0=nx34488
Xcamera_module_cache_reg_ram_89__5 dffr $PINS Q=camera_module_cache_ram_89__5
+ QB=#dummy[1715] D=nx15173 CLK=clk R=rst
Xix15174 mux21_ni $PINS Y=nx15173 A0=camera_module_cache_ram_89__5 A1=nx35486
+ S0=nx34484
Xix31791 aoi22 $PINS Y=nx31790 A0=camera_module_cache_ram_121__5 A1=nx36078
+ B0=camera_module_cache_ram_105__5 B1=nx36118
Xcamera_module_cache_reg_ram_121__5 dffr $PINS Q=camera_module_cache_ram_121__5
+ QB=#dummy[1716] D=nx15153 CLK=clk R=rst
Xix15154 mux21_ni $PINS Y=nx15153 A0=camera_module_cache_ram_121__5 A1=nx35486
+ S0=nx34476
Xcamera_module_cache_reg_ram_105__5 dffr $PINS Q=camera_module_cache_ram_105__5
+ QB=#dummy[1717] D=nx15163 CLK=clk R=rst
Xix15164 mux21_ni $PINS Y=nx15163 A0=camera_module_cache_ram_105__5 A1=nx35486
+ S0=nx34480
Xix18255 nand04 $PINS Y=nx18254 A0=nx31799 A1=nx31807 A2=nx31815 A3=nx31823
Xix31800 aoi22 $PINS Y=nx31799 A0=camera_module_cache_ram_137__5 A1=nx36158
+ B0=camera_module_cache_ram_153__5 B1=nx36198
Xcamera_module_cache_reg_ram_137__5 dffr $PINS Q=camera_module_cache_ram_137__5
+ QB=#dummy[1718] D=nx15143 CLK=clk R=rst
Xix15144 mux21_ni $PINS Y=nx15143 A0=camera_module_cache_ram_137__5 A1=nx35486
+ S0=nx34472
Xcamera_module_cache_reg_ram_153__5 dffr $PINS Q=camera_module_cache_ram_153__5
+ QB=#dummy[1719] D=nx15133 CLK=clk R=rst
Xix15134 mux21_ni $PINS Y=nx15133 A0=camera_module_cache_ram_153__5 A1=nx35486
+ S0=nx34468
Xix31808 aoi22 $PINS Y=nx31807 A0=camera_module_cache_ram_185__5 A1=nx36238
+ B0=camera_module_cache_ram_169__5 B1=nx36278
Xcamera_module_cache_reg_ram_185__5 dffr $PINS Q=camera_module_cache_ram_185__5
+ QB=#dummy[1720] D=nx15113 CLK=clk R=rst
Xix15114 mux21_ni $PINS Y=nx15113 A0=camera_module_cache_ram_185__5 A1=nx35488
+ S0=nx34460
Xcamera_module_cache_reg_ram_169__5 dffr $PINS Q=camera_module_cache_ram_169__5
+ QB=#dummy[1721] D=nx15123 CLK=clk R=rst
Xix15124 mux21_ni $PINS Y=nx15123 A0=camera_module_cache_ram_169__5 A1=nx35488
+ S0=nx34464
Xix31816 aoi22 $PINS Y=nx31815 A0=camera_module_cache_ram_201__5 A1=nx36318
+ B0=camera_module_cache_ram_217__5 B1=nx36358
Xcamera_module_cache_reg_ram_201__5 dffr $PINS Q=camera_module_cache_ram_201__5
+ QB=#dummy[1722] D=nx15103 CLK=clk R=rst
Xix15104 mux21_ni $PINS Y=nx15103 A0=camera_module_cache_ram_201__5 A1=nx35488
+ S0=nx34456
Xcamera_module_cache_reg_ram_217__5 dffr $PINS Q=camera_module_cache_ram_217__5
+ QB=#dummy[1723] D=nx15093 CLK=clk R=rst
Xix15094 mux21_ni $PINS Y=nx15093 A0=camera_module_cache_ram_217__5 A1=nx35488
+ S0=nx34452
Xix31824 aoi22 $PINS Y=nx31823 A0=camera_module_cache_ram_233__5 A1=nx36398
+ B0=camera_module_cache_ram_249__5 B1=nx36438
Xcamera_module_cache_reg_ram_233__5 dffr $PINS Q=camera_module_cache_ram_233__5
+ QB=#dummy[1724] D=nx15083 CLK=clk R=rst
Xix15084 mux21_ni $PINS Y=nx15083 A0=camera_module_cache_ram_233__5 A1=nx35488
+ S0=nx34448
Xcamera_module_cache_reg_ram_249__5 dffr $PINS Q=camera_module_cache_ram_249__5
+ QB=#dummy[1725] D=nx15073 CLK=clk R=rst
Xix15074 mux21_ni $PINS Y=nx15073 A0=camera_module_cache_ram_249__5 A1=nx35488
+ S0=nx34444
Xix31832 oai21 $PINS Y=nx31831 A0=nx18168 A1=nx18090 B0=nx36488
Xix18169 nand04 $PINS Y=nx18168 A0=nx31834 A1=nx31842 A2=nx31850 A3=nx31858
Xix31835 aoi22 $PINS Y=nx31834 A0=camera_module_cache_ram_10__5 A1=nx35838
+ B0=camera_module_cache_ram_26__5 B1=nx35878
Xcamera_module_cache_reg_ram_10__5 dffr $PINS Q=camera_module_cache_ram_10__5
+ QB=#dummy[1726] D=nx15063 CLK=clk R=rst
Xix15064 mux21_ni $PINS Y=nx15063 A0=camera_module_cache_ram_10__5 A1=nx35488
+ S0=nx34434
Xcamera_module_cache_reg_ram_26__5 dffr $PINS Q=camera_module_cache_ram_26__5
+ QB=#dummy[1727] D=nx15053 CLK=clk R=rst
Xix15054 mux21_ni $PINS Y=nx15053 A0=camera_module_cache_ram_26__5 A1=nx35490
+ S0=nx34430
Xix31843 aoi22 $PINS Y=nx31842 A0=camera_module_cache_ram_42__5 A1=nx35918
+ B0=camera_module_cache_ram_58__5 B1=nx35958
Xcamera_module_cache_reg_ram_42__5 dffr $PINS Q=camera_module_cache_ram_42__5
+ QB=#dummy[1728] D=nx15043 CLK=clk R=rst
Xix15044 mux21_ni $PINS Y=nx15043 A0=camera_module_cache_ram_42__5 A1=nx35490
+ S0=nx34426
Xcamera_module_cache_reg_ram_58__5 dffr $PINS Q=camera_module_cache_ram_58__5
+ QB=#dummy[1729] D=nx15033 CLK=clk R=rst
Xix15034 mux21_ni $PINS Y=nx15033 A0=camera_module_cache_ram_58__5 A1=nx35490
+ S0=nx34422
Xix31851 aoi22 $PINS Y=nx31850 A0=camera_module_cache_ram_74__5 A1=nx35998
+ B0=camera_module_cache_ram_90__5 B1=nx36038
Xcamera_module_cache_reg_ram_74__5 dffr $PINS Q=camera_module_cache_ram_74__5
+ QB=#dummy[1730] D=nx15023 CLK=clk R=rst
Xix15024 mux21_ni $PINS Y=nx15023 A0=camera_module_cache_ram_74__5 A1=nx35490
+ S0=nx34418
Xcamera_module_cache_reg_ram_90__5 dffr $PINS Q=camera_module_cache_ram_90__5
+ QB=#dummy[1731] D=nx15013 CLK=clk R=rst
Xix15014 mux21_ni $PINS Y=nx15013 A0=camera_module_cache_ram_90__5 A1=nx35490
+ S0=nx34414
Xix31859 aoi22 $PINS Y=nx31858 A0=camera_module_cache_ram_122__5 A1=nx36078
+ B0=camera_module_cache_ram_106__5 B1=nx36118
Xcamera_module_cache_reg_ram_122__5 dffr $PINS Q=camera_module_cache_ram_122__5
+ QB=#dummy[1732] D=nx14993 CLK=clk R=rst
Xix14994 mux21_ni $PINS Y=nx14993 A0=camera_module_cache_ram_122__5 A1=nx35490
+ S0=nx34406
Xcamera_module_cache_reg_ram_106__5 dffr $PINS Q=camera_module_cache_ram_106__5
+ QB=#dummy[1733] D=nx15003 CLK=clk R=rst
Xix15004 mux21_ni $PINS Y=nx15003 A0=camera_module_cache_ram_106__5 A1=nx35490
+ S0=nx34410
Xix18091 nand04 $PINS Y=nx18090 A0=nx31867 A1=nx31875 A2=nx31883 A3=nx31891
Xix31868 aoi22 $PINS Y=nx31867 A0=camera_module_cache_ram_138__5 A1=nx36158
+ B0=camera_module_cache_ram_154__5 B1=nx36198
Xcamera_module_cache_reg_ram_138__5 dffr $PINS Q=camera_module_cache_ram_138__5
+ QB=#dummy[1734] D=nx14983 CLK=clk R=rst
Xix14984 mux21_ni $PINS Y=nx14983 A0=camera_module_cache_ram_138__5 A1=nx35492
+ S0=nx34402
Xcamera_module_cache_reg_ram_154__5 dffr $PINS Q=camera_module_cache_ram_154__5
+ QB=#dummy[1735] D=nx14973 CLK=clk R=rst
Xix14974 mux21_ni $PINS Y=nx14973 A0=camera_module_cache_ram_154__5 A1=nx35492
+ S0=nx34398
Xix31876 aoi22 $PINS Y=nx31875 A0=camera_module_cache_ram_186__5 A1=nx36238
+ B0=camera_module_cache_ram_170__5 B1=nx36278
Xcamera_module_cache_reg_ram_186__5 dffr $PINS Q=camera_module_cache_ram_186__5
+ QB=#dummy[1736] D=nx14953 CLK=clk R=rst
Xix14954 mux21_ni $PINS Y=nx14953 A0=camera_module_cache_ram_186__5 A1=nx35492
+ S0=nx34390
Xcamera_module_cache_reg_ram_170__5 dffr $PINS Q=camera_module_cache_ram_170__5
+ QB=#dummy[1737] D=nx14963 CLK=clk R=rst
Xix14964 mux21_ni $PINS Y=nx14963 A0=camera_module_cache_ram_170__5 A1=nx35492
+ S0=nx34394
Xix31884 aoi22 $PINS Y=nx31883 A0=camera_module_cache_ram_202__5 A1=nx36318
+ B0=camera_module_cache_ram_218__5 B1=nx36358
Xcamera_module_cache_reg_ram_202__5 dffr $PINS Q=camera_module_cache_ram_202__5
+ QB=#dummy[1738] D=nx14943 CLK=clk R=rst
Xix14944 mux21_ni $PINS Y=nx14943 A0=camera_module_cache_ram_202__5 A1=nx35492
+ S0=nx34386
Xcamera_module_cache_reg_ram_218__5 dffr $PINS Q=camera_module_cache_ram_218__5
+ QB=#dummy[1739] D=nx14933 CLK=clk R=rst
Xix14934 mux21_ni $PINS Y=nx14933 A0=camera_module_cache_ram_218__5 A1=nx35492
+ S0=nx34382
Xix31892 aoi22 $PINS Y=nx31891 A0=camera_module_cache_ram_234__5 A1=nx36398
+ B0=camera_module_cache_ram_250__5 B1=nx36438
Xcamera_module_cache_reg_ram_234__5 dffr $PINS Q=camera_module_cache_ram_234__5
+ QB=#dummy[1740] D=nx14923 CLK=clk R=rst
Xix14924 mux21_ni $PINS Y=nx14923 A0=camera_module_cache_ram_234__5 A1=nx35492
+ S0=nx34378
Xcamera_module_cache_reg_ram_250__5 dffr $PINS Q=camera_module_cache_ram_250__5
+ QB=#dummy[1741] D=nx14913 CLK=clk R=rst
Xix14914 mux21_ni $PINS Y=nx14913 A0=camera_module_cache_ram_250__5 A1=nx35494
+ S0=nx34374
Xix31900 oai21 $PINS Y=nx31899 A0=nx18006 A1=nx17928 B0=nx36492
Xix18007 nand04 $PINS Y=nx18006 A0=nx31902 A1=nx31910 A2=nx31918 A3=nx31926
Xix31903 aoi22 $PINS Y=nx31902 A0=camera_module_cache_ram_11__5 A1=nx35838
+ B0=camera_module_cache_ram_27__5 B1=nx35878
Xcamera_module_cache_reg_ram_11__5 dffr $PINS Q=camera_module_cache_ram_11__5
+ QB=#dummy[1742] D=nx14903 CLK=clk R=rst
Xix14904 mux21_ni $PINS Y=nx14903 A0=camera_module_cache_ram_11__5 A1=nx35494
+ S0=nx34364
Xcamera_module_cache_reg_ram_27__5 dffr $PINS Q=camera_module_cache_ram_27__5
+ QB=#dummy[1743] D=nx14893 CLK=clk R=rst
Xix14894 mux21_ni $PINS Y=nx14893 A0=camera_module_cache_ram_27__5 A1=nx35494
+ S0=nx34360
Xix31911 aoi22 $PINS Y=nx31910 A0=camera_module_cache_ram_43__5 A1=nx35918
+ B0=camera_module_cache_ram_59__5 B1=nx35958
Xcamera_module_cache_reg_ram_43__5 dffr $PINS Q=camera_module_cache_ram_43__5
+ QB=#dummy[1744] D=nx14883 CLK=clk R=rst
Xix14884 mux21_ni $PINS Y=nx14883 A0=camera_module_cache_ram_43__5 A1=nx35494
+ S0=nx34356
Xcamera_module_cache_reg_ram_59__5 dffr $PINS Q=camera_module_cache_ram_59__5
+ QB=#dummy[1745] D=nx14873 CLK=clk R=rst
Xix14874 mux21_ni $PINS Y=nx14873 A0=camera_module_cache_ram_59__5 A1=nx35494
+ S0=nx34352
Xix31919 aoi22 $PINS Y=nx31918 A0=camera_module_cache_ram_75__5 A1=nx35998
+ B0=camera_module_cache_ram_91__5 B1=nx36038
Xcamera_module_cache_reg_ram_75__5 dffr $PINS Q=camera_module_cache_ram_75__5
+ QB=#dummy[1746] D=nx14863 CLK=clk R=rst
Xix14864 mux21_ni $PINS Y=nx14863 A0=camera_module_cache_ram_75__5 A1=nx35494
+ S0=nx34348
Xcamera_module_cache_reg_ram_91__5 dffr $PINS Q=camera_module_cache_ram_91__5
+ QB=#dummy[1747] D=nx14853 CLK=clk R=rst
Xix14854 mux21_ni $PINS Y=nx14853 A0=camera_module_cache_ram_91__5 A1=nx35494
+ S0=nx34344
Xix31927 aoi22 $PINS Y=nx31926 A0=camera_module_cache_ram_123__5 A1=nx36078
+ B0=camera_module_cache_ram_107__5 B1=nx36118
Xcamera_module_cache_reg_ram_123__5 dffr $PINS Q=camera_module_cache_ram_123__5
+ QB=#dummy[1748] D=nx14833 CLK=clk R=rst
Xix14834 mux21_ni $PINS Y=nx14833 A0=camera_module_cache_ram_123__5 A1=nx35496
+ S0=nx34336
Xcamera_module_cache_reg_ram_107__5 dffr $PINS Q=camera_module_cache_ram_107__5
+ QB=#dummy[1749] D=nx14843 CLK=clk R=rst
Xix14844 mux21_ni $PINS Y=nx14843 A0=camera_module_cache_ram_107__5 A1=nx35496
+ S0=nx34340
Xix17929 nand04 $PINS Y=nx17928 A0=nx31935 A1=nx31943 A2=nx31951 A3=nx31959
Xix31936 aoi22 $PINS Y=nx31935 A0=camera_module_cache_ram_139__5 A1=nx36158
+ B0=camera_module_cache_ram_155__5 B1=nx36198
Xcamera_module_cache_reg_ram_139__5 dffr $PINS Q=camera_module_cache_ram_139__5
+ QB=#dummy[1750] D=nx14823 CLK=clk R=rst
Xix14824 mux21_ni $PINS Y=nx14823 A0=camera_module_cache_ram_139__5 A1=nx35496
+ S0=nx34332
Xcamera_module_cache_reg_ram_155__5 dffr $PINS Q=camera_module_cache_ram_155__5
+ QB=#dummy[1751] D=nx14813 CLK=clk R=rst
Xix14814 mux21_ni $PINS Y=nx14813 A0=camera_module_cache_ram_155__5 A1=nx35496
+ S0=nx34328
Xix31944 aoi22 $PINS Y=nx31943 A0=camera_module_cache_ram_187__5 A1=nx36238
+ B0=camera_module_cache_ram_171__5 B1=nx36278
Xcamera_module_cache_reg_ram_187__5 dffr $PINS Q=camera_module_cache_ram_187__5
+ QB=#dummy[1752] D=nx14793 CLK=clk R=rst
Xix14794 mux21_ni $PINS Y=nx14793 A0=camera_module_cache_ram_187__5 A1=nx35496
+ S0=nx34320
Xcamera_module_cache_reg_ram_171__5 dffr $PINS Q=camera_module_cache_ram_171__5
+ QB=#dummy[1753] D=nx14803 CLK=clk R=rst
Xix14804 mux21_ni $PINS Y=nx14803 A0=camera_module_cache_ram_171__5 A1=nx35496
+ S0=nx34324
Xix31952 aoi22 $PINS Y=nx31951 A0=camera_module_cache_ram_203__5 A1=nx36318
+ B0=camera_module_cache_ram_219__5 B1=nx36358
Xcamera_module_cache_reg_ram_203__5 dffr $PINS Q=camera_module_cache_ram_203__5
+ QB=#dummy[1754] D=nx14783 CLK=clk R=rst
Xix14784 mux21_ni $PINS Y=nx14783 A0=camera_module_cache_ram_203__5 A1=nx35496
+ S0=nx34316
Xcamera_module_cache_reg_ram_219__5 dffr $PINS Q=camera_module_cache_ram_219__5
+ QB=#dummy[1755] D=nx14773 CLK=clk R=rst
Xix14774 mux21_ni $PINS Y=nx14773 A0=camera_module_cache_ram_219__5 A1=nx35498
+ S0=nx34312
Xix31960 aoi22 $PINS Y=nx31959 A0=camera_module_cache_ram_235__5 A1=nx36398
+ B0=camera_module_cache_ram_251__5 B1=nx36438
Xcamera_module_cache_reg_ram_235__5 dffr $PINS Q=camera_module_cache_ram_235__5
+ QB=#dummy[1756] D=nx14763 CLK=clk R=rst
Xix14764 mux21_ni $PINS Y=nx14763 A0=camera_module_cache_ram_235__5 A1=nx35498
+ S0=nx34308
Xcamera_module_cache_reg_ram_251__5 dffr $PINS Q=camera_module_cache_ram_251__5
+ QB=#dummy[1757] D=nx14753 CLK=clk R=rst
Xix14754 mux21_ni $PINS Y=nx14753 A0=camera_module_cache_ram_251__5 A1=nx35498
+ S0=nx34304
Xix17851 nand04 $PINS Y=nx17850 A0=nx31968 A1=nx32036 A2=nx32104 A3=nx32172
Xix31969 oai21 $PINS Y=nx31968 A0=nx17840 A1=nx17762 B0=nx36508
Xix17841 nand04 $PINS Y=nx17840 A0=nx31971 A1=nx31979 A2=nx31987 A3=nx31995
Xix31972 aoi22 $PINS Y=nx31971 A0=camera_module_cache_ram_12__5 A1=nx35840
+ B0=camera_module_cache_ram_28__5 B1=nx35880
Xcamera_module_cache_reg_ram_12__5 dffr $PINS Q=camera_module_cache_ram_12__5
+ QB=#dummy[1758] D=nx14743 CLK=clk R=rst
Xix14744 mux21_ni $PINS Y=nx14743 A0=nx35498 A1=camera_module_cache_ram_12__5
+ S0=nx36496
Xcamera_module_cache_reg_ram_28__5 dffr $PINS Q=camera_module_cache_ram_28__5
+ QB=#dummy[1759] D=nx14733 CLK=clk R=rst
Xix14734 mux21_ni $PINS Y=nx14733 A0=nx35498 A1=camera_module_cache_ram_28__5
+ S0=nx36510
Xix31980 aoi22 $PINS Y=nx31979 A0=camera_module_cache_ram_44__5 A1=nx35920
+ B0=camera_module_cache_ram_60__5 B1=nx35960
Xcamera_module_cache_reg_ram_44__5 dffr $PINS Q=camera_module_cache_ram_44__5
+ QB=#dummy[1760] D=nx14723 CLK=clk R=rst
Xix14724 mux21_ni $PINS Y=nx14723 A0=nx35498 A1=camera_module_cache_ram_44__5
+ S0=nx36514
Xcamera_module_cache_reg_ram_60__5 dffr $PINS Q=camera_module_cache_ram_60__5
+ QB=#dummy[1761] D=nx14713 CLK=clk R=rst
Xix14714 mux21_ni $PINS Y=nx14713 A0=nx35498 A1=camera_module_cache_ram_60__5
+ S0=nx36518
Xix31988 aoi22 $PINS Y=nx31987 A0=camera_module_cache_ram_76__5 A1=nx36000
+ B0=camera_module_cache_ram_92__5 B1=nx36040
Xcamera_module_cache_reg_ram_76__5 dffr $PINS Q=camera_module_cache_ram_76__5
+ QB=#dummy[1762] D=nx14703 CLK=clk R=rst
Xix14704 mux21_ni $PINS Y=nx14703 A0=nx35500 A1=camera_module_cache_ram_76__5
+ S0=nx36522
Xcamera_module_cache_reg_ram_92__5 dffr $PINS Q=camera_module_cache_ram_92__5
+ QB=#dummy[1763] D=nx14693 CLK=clk R=rst
Xix14694 mux21_ni $PINS Y=nx14693 A0=nx35500 A1=camera_module_cache_ram_92__5
+ S0=nx36526
Xix31996 aoi22 $PINS Y=nx31995 A0=camera_module_cache_ram_124__5 A1=nx36080
+ B0=camera_module_cache_ram_108__5 B1=nx36120
Xcamera_module_cache_reg_ram_124__5 dffr $PINS Q=camera_module_cache_ram_124__5
+ QB=#dummy[1764] D=nx14673 CLK=clk R=rst
Xix14674 mux21_ni $PINS Y=nx14673 A0=nx35500 A1=camera_module_cache_ram_124__5
+ S0=nx36530
Xcamera_module_cache_reg_ram_108__5 dffr $PINS Q=camera_module_cache_ram_108__5
+ QB=#dummy[1765] D=nx14683 CLK=clk R=rst
Xix14684 mux21_ni $PINS Y=nx14683 A0=nx35500 A1=camera_module_cache_ram_108__5
+ S0=nx36534
Xix17763 nand04 $PINS Y=nx17762 A0=nx32004 A1=nx32012 A2=nx32020 A3=nx32028
Xix32005 aoi22 $PINS Y=nx32004 A0=camera_module_cache_ram_140__5 A1=nx36160
+ B0=camera_module_cache_ram_156__5 B1=nx36200
Xcamera_module_cache_reg_ram_140__5 dffr $PINS Q=camera_module_cache_ram_140__5
+ QB=#dummy[1766] D=nx14663 CLK=clk R=rst
Xix14664 mux21_ni $PINS Y=nx14663 A0=nx35500 A1=camera_module_cache_ram_140__5
+ S0=nx36538
Xcamera_module_cache_reg_ram_156__5 dffr $PINS Q=camera_module_cache_ram_156__5
+ QB=#dummy[1767] D=nx14653 CLK=clk R=rst
Xix14654 mux21_ni $PINS Y=nx14653 A0=nx35500 A1=camera_module_cache_ram_156__5
+ S0=nx36542
Xix32013 aoi22 $PINS Y=nx32012 A0=camera_module_cache_ram_188__5 A1=nx36240
+ B0=camera_module_cache_ram_172__5 B1=nx36280
Xcamera_module_cache_reg_ram_188__5 dffr $PINS Q=camera_module_cache_ram_188__5
+ QB=#dummy[1768] D=nx14633 CLK=clk R=rst
Xix14634 mux21_ni $PINS Y=nx14633 A0=nx35500 A1=camera_module_cache_ram_188__5
+ S0=nx36546
Xcamera_module_cache_reg_ram_172__5 dffr $PINS Q=camera_module_cache_ram_172__5
+ QB=#dummy[1769] D=nx14643 CLK=clk R=rst
Xix14644 mux21_ni $PINS Y=nx14643 A0=nx35502 A1=camera_module_cache_ram_172__5
+ S0=nx36550
Xix32021 aoi22 $PINS Y=nx32020 A0=camera_module_cache_ram_204__5 A1=nx36320
+ B0=camera_module_cache_ram_220__5 B1=nx36360
Xcamera_module_cache_reg_ram_204__5 dffr $PINS Q=camera_module_cache_ram_204__5
+ QB=#dummy[1770] D=nx14623 CLK=clk R=rst
Xix14624 mux21_ni $PINS Y=nx14623 A0=nx35502 A1=camera_module_cache_ram_204__5
+ S0=nx36554
Xcamera_module_cache_reg_ram_220__5 dffr $PINS Q=camera_module_cache_ram_220__5
+ QB=#dummy[1771] D=nx14613 CLK=clk R=rst
Xix14614 mux21_ni $PINS Y=nx14613 A0=nx35502 A1=camera_module_cache_ram_220__5
+ S0=nx36558
Xix32029 aoi22 $PINS Y=nx32028 A0=camera_module_cache_ram_236__5 A1=nx36400
+ B0=camera_module_cache_ram_252__5 B1=nx36440
Xcamera_module_cache_reg_ram_236__5 dffr $PINS Q=camera_module_cache_ram_236__5
+ QB=#dummy[1772] D=nx14603 CLK=clk R=rst
Xix14604 mux21_ni $PINS Y=nx14603 A0=nx35502 A1=camera_module_cache_ram_236__5
+ S0=nx36562
Xcamera_module_cache_reg_ram_252__5 dffr $PINS Q=camera_module_cache_ram_252__5
+ QB=#dummy[1773] D=nx14593 CLK=clk R=rst
Xix14594 mux21_ni $PINS Y=nx14593 A0=nx35502 A1=camera_module_cache_ram_252__5
+ S0=nx36566
Xix32037 oai21 $PINS Y=nx32036 A0=nx17678 A1=nx17600 B0=nx36582
Xix17679 nand04 $PINS Y=nx17678 A0=nx32039 A1=nx32047 A2=nx32055 A3=nx32063
Xix32040 aoi22 $PINS Y=nx32039 A0=camera_module_cache_ram_13__5 A1=nx35840
+ B0=camera_module_cache_ram_29__5 B1=nx35880
Xcamera_module_cache_reg_ram_13__5 dffr $PINS Q=camera_module_cache_ram_13__5
+ QB=#dummy[1774] D=nx14583 CLK=clk R=rst
Xix14584 mux21_ni $PINS Y=nx14583 A0=nx35502 A1=camera_module_cache_ram_13__5
+ S0=nx36570
Xcamera_module_cache_reg_ram_29__5 dffr $PINS Q=camera_module_cache_ram_29__5
+ QB=#dummy[1775] D=nx14573 CLK=clk R=rst
Xix14574 mux21_ni $PINS Y=nx14573 A0=nx35502 A1=camera_module_cache_ram_29__5
+ S0=nx36584
Xix32048 aoi22 $PINS Y=nx32047 A0=camera_module_cache_ram_45__5 A1=nx35920
+ B0=camera_module_cache_ram_61__5 B1=nx35960
Xcamera_module_cache_reg_ram_45__5 dffr $PINS Q=camera_module_cache_ram_45__5
+ QB=#dummy[1776] D=nx14563 CLK=clk R=rst
Xix14564 mux21_ni $PINS Y=nx14563 A0=nx35504 A1=camera_module_cache_ram_45__5
+ S0=nx36588
Xcamera_module_cache_reg_ram_61__5 dffr $PINS Q=camera_module_cache_ram_61__5
+ QB=#dummy[1777] D=nx14553 CLK=clk R=rst
Xix14554 mux21_ni $PINS Y=nx14553 A0=nx35504 A1=camera_module_cache_ram_61__5
+ S0=nx36592
Xix32056 aoi22 $PINS Y=nx32055 A0=camera_module_cache_ram_77__5 A1=nx36000
+ B0=camera_module_cache_ram_93__5 B1=nx36040
Xcamera_module_cache_reg_ram_77__5 dffr $PINS Q=camera_module_cache_ram_77__5
+ QB=#dummy[1778] D=nx14543 CLK=clk R=rst
Xix14544 mux21_ni $PINS Y=nx14543 A0=nx35504 A1=camera_module_cache_ram_77__5
+ S0=nx36596
Xcamera_module_cache_reg_ram_93__5 dffr $PINS Q=camera_module_cache_ram_93__5
+ QB=#dummy[1779] D=nx14533 CLK=clk R=rst
Xix14534 mux21_ni $PINS Y=nx14533 A0=nx35504 A1=camera_module_cache_ram_93__5
+ S0=nx36600
Xix32064 aoi22 $PINS Y=nx32063 A0=camera_module_cache_ram_125__5 A1=nx36080
+ B0=camera_module_cache_ram_109__5 B1=nx36120
Xcamera_module_cache_reg_ram_125__5 dffr $PINS Q=camera_module_cache_ram_125__5
+ QB=#dummy[1780] D=nx14513 CLK=clk R=rst
Xix14514 mux21_ni $PINS Y=nx14513 A0=nx35504 A1=camera_module_cache_ram_125__5
+ S0=nx36604
Xcamera_module_cache_reg_ram_109__5 dffr $PINS Q=camera_module_cache_ram_109__5
+ QB=#dummy[1781] D=nx14523 CLK=clk R=rst
Xix14524 mux21_ni $PINS Y=nx14523 A0=nx35504 A1=camera_module_cache_ram_109__5
+ S0=nx36608
Xix17601 nand04 $PINS Y=nx17600 A0=nx32072 A1=nx32080 A2=nx32088 A3=nx32096
Xix32073 aoi22 $PINS Y=nx32072 A0=camera_module_cache_ram_141__5 A1=nx36160
+ B0=camera_module_cache_ram_157__5 B1=nx36200
Xcamera_module_cache_reg_ram_141__5 dffr $PINS Q=camera_module_cache_ram_141__5
+ QB=#dummy[1782] D=nx14503 CLK=clk R=rst
Xix14504 mux21_ni $PINS Y=nx14503 A0=nx35504 A1=camera_module_cache_ram_141__5
+ S0=nx36612
Xcamera_module_cache_reg_ram_157__5 dffr $PINS Q=camera_module_cache_ram_157__5
+ QB=#dummy[1783] D=nx14493 CLK=clk R=rst
Xix14494 mux21_ni $PINS Y=nx14493 A0=nx35506 A1=camera_module_cache_ram_157__5
+ S0=nx36616
Xix32081 aoi22 $PINS Y=nx32080 A0=camera_module_cache_ram_189__5 A1=nx36240
+ B0=camera_module_cache_ram_173__5 B1=nx36280
Xcamera_module_cache_reg_ram_189__5 dffr $PINS Q=camera_module_cache_ram_189__5
+ QB=#dummy[1784] D=nx14473 CLK=clk R=rst
Xix14474 mux21_ni $PINS Y=nx14473 A0=nx35506 A1=camera_module_cache_ram_189__5
+ S0=nx36620
Xcamera_module_cache_reg_ram_173__5 dffr $PINS Q=camera_module_cache_ram_173__5
+ QB=#dummy[1785] D=nx14483 CLK=clk R=rst
Xix14484 mux21_ni $PINS Y=nx14483 A0=nx35506 A1=camera_module_cache_ram_173__5
+ S0=nx36624
Xix32089 aoi22 $PINS Y=nx32088 A0=camera_module_cache_ram_205__5 A1=nx36320
+ B0=camera_module_cache_ram_221__5 B1=nx36360
Xcamera_module_cache_reg_ram_205__5 dffr $PINS Q=camera_module_cache_ram_205__5
+ QB=#dummy[1786] D=nx14463 CLK=clk R=rst
Xix14464 mux21_ni $PINS Y=nx14463 A0=nx35506 A1=camera_module_cache_ram_205__5
+ S0=nx36628
Xcamera_module_cache_reg_ram_221__5 dffr $PINS Q=camera_module_cache_ram_221__5
+ QB=#dummy[1787] D=nx14453 CLK=clk R=rst
Xix14454 mux21_ni $PINS Y=nx14453 A0=nx35506 A1=camera_module_cache_ram_221__5
+ S0=nx36632
Xix32097 aoi22 $PINS Y=nx32096 A0=camera_module_cache_ram_237__5 A1=nx36400
+ B0=camera_module_cache_ram_253__5 B1=nx36440
Xcamera_module_cache_reg_ram_237__5 dffr $PINS Q=camera_module_cache_ram_237__5
+ QB=#dummy[1788] D=nx14443 CLK=clk R=rst
Xix14444 mux21_ni $PINS Y=nx14443 A0=nx35506 A1=camera_module_cache_ram_237__5
+ S0=nx36636
Xcamera_module_cache_reg_ram_253__5 dffr $PINS Q=camera_module_cache_ram_253__5
+ QB=#dummy[1789] D=nx14433 CLK=clk R=rst
Xix14434 mux21_ni $PINS Y=nx14433 A0=nx35506 A1=camera_module_cache_ram_253__5
+ S0=nx36640
Xix32105 oai21 $PINS Y=nx32104 A0=nx17514 A1=nx17436 B0=nx36656
Xix17515 nand04 $PINS Y=nx17514 A0=nx32107 A1=nx32115 A2=nx32123 A3=nx32131
Xix32108 aoi22 $PINS Y=nx32107 A0=camera_module_cache_ram_14__5 A1=nx35840
+ B0=camera_module_cache_ram_30__5 B1=nx35880
Xcamera_module_cache_reg_ram_14__5 dffr $PINS Q=camera_module_cache_ram_14__5
+ QB=#dummy[1790] D=nx14423 CLK=clk R=rst
Xix14424 mux21_ni $PINS Y=nx14423 A0=nx35508 A1=camera_module_cache_ram_14__5
+ S0=nx36644
Xcamera_module_cache_reg_ram_30__5 dffr $PINS Q=camera_module_cache_ram_30__5
+ QB=#dummy[1791] D=nx14413 CLK=clk R=rst
Xix14414 mux21_ni $PINS Y=nx14413 A0=nx35508 A1=camera_module_cache_ram_30__5
+ S0=nx36658
Xix32116 aoi22 $PINS Y=nx32115 A0=camera_module_cache_ram_46__5 A1=nx35920
+ B0=camera_module_cache_ram_62__5 B1=nx35960
Xcamera_module_cache_reg_ram_46__5 dffr $PINS Q=camera_module_cache_ram_46__5
+ QB=#dummy[1792] D=nx14403 CLK=clk R=rst
Xix14404 mux21_ni $PINS Y=nx14403 A0=nx35508 A1=camera_module_cache_ram_46__5
+ S0=nx36662
Xcamera_module_cache_reg_ram_62__5 dffr $PINS Q=camera_module_cache_ram_62__5
+ QB=#dummy[1793] D=nx14393 CLK=clk R=rst
Xix14394 mux21_ni $PINS Y=nx14393 A0=nx35508 A1=camera_module_cache_ram_62__5
+ S0=nx36666
Xix32124 aoi22 $PINS Y=nx32123 A0=camera_module_cache_ram_78__5 A1=nx36000
+ B0=camera_module_cache_ram_94__5 B1=nx36040
Xcamera_module_cache_reg_ram_78__5 dffr $PINS Q=camera_module_cache_ram_78__5
+ QB=#dummy[1794] D=nx14383 CLK=clk R=rst
Xix14384 mux21_ni $PINS Y=nx14383 A0=nx35508 A1=camera_module_cache_ram_78__5
+ S0=nx36670
Xcamera_module_cache_reg_ram_94__5 dffr $PINS Q=camera_module_cache_ram_94__5
+ QB=#dummy[1795] D=nx14373 CLK=clk R=rst
Xix14374 mux21_ni $PINS Y=nx14373 A0=nx35508 A1=camera_module_cache_ram_94__5
+ S0=nx36674
Xix32132 aoi22 $PINS Y=nx32131 A0=camera_module_cache_ram_126__5 A1=nx36080
+ B0=camera_module_cache_ram_110__5 B1=nx36120
Xcamera_module_cache_reg_ram_126__5 dffr $PINS Q=camera_module_cache_ram_126__5
+ QB=#dummy[1796] D=nx14353 CLK=clk R=rst
Xix14354 mux21_ni $PINS Y=nx14353 A0=nx35508 A1=camera_module_cache_ram_126__5
+ S0=nx36678
Xcamera_module_cache_reg_ram_110__5 dffr $PINS Q=camera_module_cache_ram_110__5
+ QB=#dummy[1797] D=nx14363 CLK=clk R=rst
Xix14364 mux21_ni $PINS Y=nx14363 A0=nx35510 A1=camera_module_cache_ram_110__5
+ S0=nx36682
Xix17437 nand04 $PINS Y=nx17436 A0=nx32140 A1=nx32148 A2=nx32156 A3=nx32164
Xix32141 aoi22 $PINS Y=nx32140 A0=camera_module_cache_ram_142__5 A1=nx36160
+ B0=camera_module_cache_ram_158__5 B1=nx36200
Xcamera_module_cache_reg_ram_142__5 dffr $PINS Q=camera_module_cache_ram_142__5
+ QB=#dummy[1798] D=nx14343 CLK=clk R=rst
Xix14344 mux21_ni $PINS Y=nx14343 A0=nx35510 A1=camera_module_cache_ram_142__5
+ S0=nx36686
Xcamera_module_cache_reg_ram_158__5 dffr $PINS Q=camera_module_cache_ram_158__5
+ QB=#dummy[1799] D=nx14333 CLK=clk R=rst
Xix14334 mux21_ni $PINS Y=nx14333 A0=nx35510 A1=camera_module_cache_ram_158__5
+ S0=nx36690
Xix32149 aoi22 $PINS Y=nx32148 A0=camera_module_cache_ram_190__5 A1=nx36240
+ B0=camera_module_cache_ram_174__5 B1=nx36280
Xcamera_module_cache_reg_ram_190__5 dffr $PINS Q=camera_module_cache_ram_190__5
+ QB=#dummy[1800] D=nx14313 CLK=clk R=rst
Xix14314 mux21_ni $PINS Y=nx14313 A0=nx35510 A1=camera_module_cache_ram_190__5
+ S0=nx36694
Xcamera_module_cache_reg_ram_174__5 dffr $PINS Q=camera_module_cache_ram_174__5
+ QB=#dummy[1801] D=nx14323 CLK=clk R=rst
Xix14324 mux21_ni $PINS Y=nx14323 A0=nx35510 A1=camera_module_cache_ram_174__5
+ S0=nx36698
Xix32157 aoi22 $PINS Y=nx32156 A0=camera_module_cache_ram_206__5 A1=nx36320
+ B0=camera_module_cache_ram_222__5 B1=nx36360
Xcamera_module_cache_reg_ram_206__5 dffr $PINS Q=camera_module_cache_ram_206__5
+ QB=#dummy[1802] D=nx14303 CLK=clk R=rst
Xix14304 mux21_ni $PINS Y=nx14303 A0=nx35510 A1=camera_module_cache_ram_206__5
+ S0=nx36702
Xcamera_module_cache_reg_ram_222__5 dffr $PINS Q=camera_module_cache_ram_222__5
+ QB=#dummy[1803] D=nx14293 CLK=clk R=rst
Xix14294 mux21_ni $PINS Y=nx14293 A0=nx35510 A1=camera_module_cache_ram_222__5
+ S0=nx36706
Xix32165 aoi22 $PINS Y=nx32164 A0=camera_module_cache_ram_238__5 A1=nx36400
+ B0=camera_module_cache_ram_254__5 B1=nx36440
Xcamera_module_cache_reg_ram_238__5 dffr $PINS Q=camera_module_cache_ram_238__5
+ QB=#dummy[1804] D=nx14283 CLK=clk R=rst
Xix14284 mux21_ni $PINS Y=nx14283 A0=nx35512 A1=camera_module_cache_ram_238__5
+ S0=nx36710
Xcamera_module_cache_reg_ram_254__5 dffr $PINS Q=camera_module_cache_ram_254__5
+ QB=#dummy[1805] D=nx14273 CLK=clk R=rst
Xix14274 mux21_ni $PINS Y=nx14273 A0=nx35512 A1=camera_module_cache_ram_254__5
+ S0=nx36714
Xix32173 oai21 $PINS Y=nx32172 A0=nx17352 A1=nx17274 B0=nx36730
Xix17353 nand04 $PINS Y=nx17352 A0=nx32175 A1=nx32183 A2=nx32191 A3=nx32199
Xix32176 aoi22 $PINS Y=nx32175 A0=camera_module_cache_ram_15__5 A1=nx35840
+ B0=camera_module_cache_ram_31__5 B1=nx35880
Xcamera_module_cache_reg_ram_15__5 dffr $PINS Q=camera_module_cache_ram_15__5
+ QB=#dummy[1806] D=nx14263 CLK=clk R=rst
Xix14264 mux21_ni $PINS Y=nx14263 A0=nx35512 A1=camera_module_cache_ram_15__5
+ S0=nx36718
Xcamera_module_cache_reg_ram_31__5 dffr $PINS Q=camera_module_cache_ram_31__5
+ QB=#dummy[1807] D=nx14253 CLK=clk R=rst
Xix14254 mux21_ni $PINS Y=nx14253 A0=nx35512 A1=camera_module_cache_ram_31__5
+ S0=nx36732
Xix32184 aoi22 $PINS Y=nx32183 A0=camera_module_cache_ram_47__5 A1=nx35920
+ B0=camera_module_cache_ram_63__5 B1=nx35960
Xcamera_module_cache_reg_ram_47__5 dffr $PINS Q=camera_module_cache_ram_47__5
+ QB=#dummy[1808] D=nx14243 CLK=clk R=rst
Xix14244 mux21_ni $PINS Y=nx14243 A0=nx35512 A1=camera_module_cache_ram_47__5
+ S0=nx36736
Xcamera_module_cache_reg_ram_63__5 dffr $PINS Q=camera_module_cache_ram_63__5
+ QB=#dummy[1809] D=nx14233 CLK=clk R=rst
Xix14234 mux21_ni $PINS Y=nx14233 A0=nx35512 A1=camera_module_cache_ram_63__5
+ S0=nx36740
Xix32192 aoi22 $PINS Y=nx32191 A0=camera_module_cache_ram_79__5 A1=nx36000
+ B0=camera_module_cache_ram_95__5 B1=nx36040
Xcamera_module_cache_reg_ram_79__5 dffr $PINS Q=camera_module_cache_ram_79__5
+ QB=#dummy[1810] D=nx14223 CLK=clk R=rst
Xix14224 mux21_ni $PINS Y=nx14223 A0=nx35512 A1=camera_module_cache_ram_79__5
+ S0=nx36744
Xcamera_module_cache_reg_ram_95__5 dffr $PINS Q=camera_module_cache_ram_95__5
+ QB=#dummy[1811] D=nx14213 CLK=clk R=rst
Xix14214 mux21_ni $PINS Y=nx14213 A0=nx35514 A1=camera_module_cache_ram_95__5
+ S0=nx36748
Xix32200 aoi22 $PINS Y=nx32199 A0=camera_module_cache_ram_127__5 A1=nx36080
+ B0=camera_module_cache_ram_111__5 B1=nx36120
Xcamera_module_cache_reg_ram_127__5 dffr $PINS Q=camera_module_cache_ram_127__5
+ QB=#dummy[1812] D=nx14193 CLK=clk R=rst
Xix14194 mux21_ni $PINS Y=nx14193 A0=nx35514 A1=camera_module_cache_ram_127__5
+ S0=nx36752
Xcamera_module_cache_reg_ram_111__5 dffr $PINS Q=camera_module_cache_ram_111__5
+ QB=#dummy[1813] D=nx14203 CLK=clk R=rst
Xix14204 mux21_ni $PINS Y=nx14203 A0=nx35514 A1=camera_module_cache_ram_111__5
+ S0=nx36756
Xix17275 nand04 $PINS Y=nx17274 A0=nx32208 A1=nx32216 A2=nx32224 A3=nx32232
Xix32209 aoi22 $PINS Y=nx32208 A0=camera_module_cache_ram_143__5 A1=nx36160
+ B0=camera_module_cache_ram_159__5 B1=nx36200
Xcamera_module_cache_reg_ram_143__5 dffr $PINS Q=camera_module_cache_ram_143__5
+ QB=#dummy[1814] D=nx14183 CLK=clk R=rst
Xix14184 mux21_ni $PINS Y=nx14183 A0=nx35514 A1=camera_module_cache_ram_143__5
+ S0=nx36760
Xcamera_module_cache_reg_ram_159__5 dffr $PINS Q=camera_module_cache_ram_159__5
+ QB=#dummy[1815] D=nx14173 CLK=clk R=rst
Xix14174 mux21_ni $PINS Y=nx14173 A0=nx35514 A1=camera_module_cache_ram_159__5
+ S0=nx36764
Xix32217 aoi22 $PINS Y=nx32216 A0=camera_module_cache_ram_191__5 A1=nx36240
+ B0=camera_module_cache_ram_175__5 B1=nx36280
Xcamera_module_cache_reg_ram_191__5 dffr $PINS Q=camera_module_cache_ram_191__5
+ QB=#dummy[1816] D=nx14153 CLK=clk R=rst
Xix14154 mux21_ni $PINS Y=nx14153 A0=nx35514 A1=camera_module_cache_ram_191__5
+ S0=nx36768
Xcamera_module_cache_reg_ram_175__5 dffr $PINS Q=camera_module_cache_ram_175__5
+ QB=#dummy[1817] D=nx14163 CLK=clk R=rst
Xix14164 mux21_ni $PINS Y=nx14163 A0=nx35514 A1=camera_module_cache_ram_175__5
+ S0=nx36772
Xix32225 aoi22 $PINS Y=nx32224 A0=camera_module_cache_ram_207__5 A1=nx36320
+ B0=camera_module_cache_ram_223__5 B1=nx36360
Xcamera_module_cache_reg_ram_207__5 dffr $PINS Q=camera_module_cache_ram_207__5
+ QB=#dummy[1818] D=nx14143 CLK=clk R=rst
Xix14144 mux21_ni $PINS Y=nx14143 A0=nx35516 A1=camera_module_cache_ram_207__5
+ S0=nx36776
Xcamera_module_cache_reg_ram_223__5 dffr $PINS Q=camera_module_cache_ram_223__5
+ QB=#dummy[1819] D=nx14133 CLK=clk R=rst
Xix14134 mux21_ni $PINS Y=nx14133 A0=nx35516 A1=camera_module_cache_ram_223__5
+ S0=nx36780
Xix32233 aoi22 $PINS Y=nx32232 A0=camera_module_cache_ram_239__5 A1=nx36400
+ B0=camera_module_cache_ram_255__5 B1=nx36440
Xcamera_module_cache_reg_ram_239__5 dffr $PINS Q=camera_module_cache_ram_239__5
+ QB=#dummy[1820] D=nx14123 CLK=clk R=rst
Xix14124 mux21_ni $PINS Y=nx14123 A0=nx35516 A1=camera_module_cache_ram_239__5
+ S0=nx36784
Xcamera_module_cache_reg_ram_255__5 dffr $PINS Q=camera_module_cache_ram_255__5
+ QB=#dummy[1821] D=nx14113 CLK=clk R=rst
Xix14114 mux21_ni $PINS Y=nx14113 A0=nx35516 A1=camera_module_cache_ram_255__5
+ S0=nx36788
Xcamera_module_algo_module_pixel_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_pixel_value_7 QB=nx33382 D=nx21813 CLK=clk
Xix21814 mux21_ni $PINS Y=nx21813 A0=nx25382
+ A1=camera_module_algo_module_pixel_value_7 S0=nx22665
Xix32249 mux21_ni $PINS Y=nx32248 A0=nx32250 A1=nx35678 S0=nx36794
Xix32251 nor04 $PINS Y=nx32250 A0=nx25362 A1=nx24708 A2=nx24052 A3=nx23398
Xix25363 nand04 $PINS Y=nx25362 A0=nx32253 A1=nx32359 A2=nx32427 A3=nx32495
Xix32254 oai21 $PINS Y=nx32253 A0=nx25352 A1=nx25274 B0=nx37232
Xix25353 nand04 $PINS Y=nx25352 A0=nx32256 A1=nx32302 A2=nx32310 A3=nx32318
Xix32257 aoi22 $PINS Y=nx32256 A0=camera_module_cache_ram_0__7 A1=nx35840
+ B0=camera_module_cache_ram_16__7 B1=nx35880
Xcamera_module_cache_reg_ram_0__7 dffr $PINS Q=camera_module_cache_ram_0__7
+ QB=#dummy[1822] D=nx21803 CLK=clk R=rst
Xix21804 mux21_ni $PINS Y=nx21803 A0=camera_module_cache_ram_0__7 A1=nx35596
+ S0=nx35136
Xix22745 oai221 $PINS Y=nx22744 A0=nx34076 A1=nx32261 B0=nx32277 B1=nx35714
+ C0=nx32280
Xnvm_module_tri_dataout_127 tri01 $PINS Y=nvm_data_127 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_119 tri01 $PINS Y=nvm_data_119 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_111 tri01 $PINS Y=nvm_data_111 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_103 tri01 $PINS Y=nvm_data_103 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_95 tri01 $PINS Y=nvm_data_95 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_87 tri01 $PINS Y=nvm_data_87 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_79 tri01 $PINS Y=nvm_data_79 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_71 tri01 $PINS Y=nvm_data_71 A=nx22549
+ E=nvm_module_GND0
Xix32278 inv01 $PINS Y=nx32277 A=nvm_data_7
Xnvm_module_tri_dataout_7 tri01 $PINS Y=nvm_data_7 A=nx22549 E=nvm_module_GND0
Xix32281 nand02 $PINS Y=nx32280 A0=nx34076 A1=nx22678
Xnvm_module_tri_dataout_63 tri01 $PINS Y=nvm_data_63 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_55 tri01 $PINS Y=nvm_data_55 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_47 tri01 $PINS Y=nvm_data_47 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_39 tri01 $PINS Y=nvm_data_39 A=nx22549
+ E=nvm_module_GND0
Xix22647 oai22 $PINS Y=nx22646 A0=nx34110 A1=nx32291 B0=nx34096 B1=nx32295
Xnvm_module_tri_dataout_31 tri01 $PINS Y=nvm_data_31 A=nx22549
+ E=nvm_module_GND0
Xnvm_module_tri_dataout_23 tri01 $PINS Y=nvm_data_23 A=nx22549
+ E=nvm_module_GND0
Xix32296 nand02 $PINS Y=nx32295 A0=nvm_data_15 A1=nx34110
Xnvm_module_tri_dataout_15 tri01 $PINS Y=nvm_data_15 A=nx22549
+ E=nvm_module_GND0
Xcamera_module_cache_reg_ram_16__7 dffr $PINS Q=camera_module_cache_ram_16__7
+ QB=#dummy[1823] D=nx21793 CLK=clk R=rst
Xix21794 mux21_ni $PINS Y=nx21793 A0=camera_module_cache_ram_16__7 A1=nx35596
+ S0=nx35132
Xix32303 aoi22 $PINS Y=nx32302 A0=camera_module_cache_ram_32__7 A1=nx35920
+ B0=camera_module_cache_ram_48__7 B1=nx35960
Xcamera_module_cache_reg_ram_32__7 dffr $PINS Q=camera_module_cache_ram_32__7
+ QB=#dummy[1824] D=nx21783 CLK=clk R=rst
Xix21784 mux21_ni $PINS Y=nx21783 A0=camera_module_cache_ram_32__7 A1=nx35596
+ S0=nx35128
Xcamera_module_cache_reg_ram_48__7 dffr $PINS Q=camera_module_cache_ram_48__7
+ QB=#dummy[1825] D=nx21773 CLK=clk R=rst
Xix21774 mux21_ni $PINS Y=nx21773 A0=camera_module_cache_ram_48__7 A1=nx35596
+ S0=nx35124
Xix32311 aoi22 $PINS Y=nx32310 A0=camera_module_cache_ram_64__7 A1=nx36000
+ B0=camera_module_cache_ram_80__7 B1=nx36040
Xcamera_module_cache_reg_ram_64__7 dffr $PINS Q=camera_module_cache_ram_64__7
+ QB=#dummy[1826] D=nx21763 CLK=clk R=rst
Xix21764 mux21_ni $PINS Y=nx21763 A0=camera_module_cache_ram_64__7 A1=nx35596
+ S0=nx35120
Xcamera_module_cache_reg_ram_80__7 dffr $PINS Q=camera_module_cache_ram_80__7
+ QB=#dummy[1827] D=nx21753 CLK=clk R=rst
Xix21754 mux21_ni $PINS Y=nx21753 A0=camera_module_cache_ram_80__7 A1=nx35596
+ S0=nx35116
Xix32319 aoi22 $PINS Y=nx32318 A0=camera_module_cache_ram_112__7 A1=nx36080
+ B0=camera_module_cache_ram_96__7 B1=nx36120
Xcamera_module_cache_reg_ram_112__7 dffr $PINS Q=camera_module_cache_ram_112__7
+ QB=#dummy[1828] D=nx21733 CLK=clk R=rst
Xix21734 mux21_ni $PINS Y=nx21733 A0=camera_module_cache_ram_112__7 A1=nx35596
+ S0=nx35108
Xcamera_module_cache_reg_ram_96__7 dffr $PINS Q=camera_module_cache_ram_96__7
+ QB=#dummy[1829] D=nx21743 CLK=clk R=rst
Xix21744 mux21_ni $PINS Y=nx21743 A0=camera_module_cache_ram_96__7 A1=nx35598
+ S0=nx35112
Xix25275 nand04 $PINS Y=nx25274 A0=nx32327 A1=nx32335 A2=nx32343 A3=nx32351
Xix32328 aoi22 $PINS Y=nx32327 A0=camera_module_cache_ram_128__7 A1=nx36160
+ B0=camera_module_cache_ram_144__7 B1=nx36200
Xcamera_module_cache_reg_ram_128__7 dffr $PINS Q=camera_module_cache_ram_128__7
+ QB=#dummy[1830] D=nx21723 CLK=clk R=rst
Xix21724 mux21_ni $PINS Y=nx21723 A0=camera_module_cache_ram_128__7 A1=nx35598
+ S0=nx35104
Xcamera_module_cache_reg_ram_144__7 dffr $PINS Q=camera_module_cache_ram_144__7
+ QB=#dummy[1831] D=nx21713 CLK=clk R=rst
Xix21714 mux21_ni $PINS Y=nx21713 A0=camera_module_cache_ram_144__7 A1=nx35598
+ S0=nx35100
Xix32336 aoi22 $PINS Y=nx32335 A0=camera_module_cache_ram_176__7 A1=nx36240
+ B0=camera_module_cache_ram_160__7 B1=nx36280
Xcamera_module_cache_reg_ram_176__7 dffr $PINS Q=camera_module_cache_ram_176__7
+ QB=#dummy[1832] D=nx21693 CLK=clk R=rst
Xix21694 mux21_ni $PINS Y=nx21693 A0=camera_module_cache_ram_176__7 A1=nx35598
+ S0=nx35092
Xcamera_module_cache_reg_ram_160__7 dffr $PINS Q=camera_module_cache_ram_160__7
+ QB=#dummy[1833] D=nx21703 CLK=clk R=rst
Xix21704 mux21_ni $PINS Y=nx21703 A0=camera_module_cache_ram_160__7 A1=nx35598
+ S0=nx35096
Xix32344 aoi22 $PINS Y=nx32343 A0=camera_module_cache_ram_192__7 A1=nx36320
+ B0=camera_module_cache_ram_208__7 B1=nx36360
Xcamera_module_cache_reg_ram_192__7 dffr $PINS Q=camera_module_cache_ram_192__7
+ QB=#dummy[1834] D=nx21683 CLK=clk R=rst
Xix21684 mux21_ni $PINS Y=nx21683 A0=camera_module_cache_ram_192__7 A1=nx35598
+ S0=nx35088
Xcamera_module_cache_reg_ram_208__7 dffr $PINS Q=camera_module_cache_ram_208__7
+ QB=#dummy[1835] D=nx21673 CLK=clk R=rst
Xix21674 mux21_ni $PINS Y=nx21673 A0=camera_module_cache_ram_208__7 A1=nx35598
+ S0=nx35084
Xix32352 aoi22 $PINS Y=nx32351 A0=camera_module_cache_ram_224__7 A1=nx36400
+ B0=camera_module_cache_ram_240__7 B1=nx36440
Xcamera_module_cache_reg_ram_224__7 dffr $PINS Q=camera_module_cache_ram_224__7
+ QB=#dummy[1836] D=nx21663 CLK=clk R=rst
Xix21664 mux21_ni $PINS Y=nx21663 A0=camera_module_cache_ram_224__7 A1=nx35600
+ S0=nx35080
Xcamera_module_cache_reg_ram_240__7 dffr $PINS Q=camera_module_cache_ram_240__7
+ QB=#dummy[1837] D=nx21653 CLK=clk R=rst
Xix21654 mux21_ni $PINS Y=nx21653 A0=camera_module_cache_ram_240__7 A1=nx35600
+ S0=nx35076
Xix32360 oai21 $PINS Y=nx32359 A0=nx25190 A1=nx25112 B0=nx37236
Xix25191 nand04 $PINS Y=nx25190 A0=nx32362 A1=nx32370 A2=nx32378 A3=nx32386
Xix32363 aoi22 $PINS Y=nx32362 A0=camera_module_cache_ram_1__7 A1=nx35840
+ B0=camera_module_cache_ram_17__7 B1=nx35880
Xcamera_module_cache_reg_ram_1__7 dffr $PINS Q=camera_module_cache_ram_1__7
+ QB=#dummy[1838] D=nx21643 CLK=clk R=rst
Xix21644 mux21_ni $PINS Y=nx21643 A0=camera_module_cache_ram_1__7 A1=nx35600
+ S0=nx35066
Xcamera_module_cache_reg_ram_17__7 dffr $PINS Q=camera_module_cache_ram_17__7
+ QB=#dummy[1839] D=nx21633 CLK=clk R=rst
Xix21634 mux21_ni $PINS Y=nx21633 A0=camera_module_cache_ram_17__7 A1=nx35600
+ S0=nx35062
Xix32371 aoi22 $PINS Y=nx32370 A0=camera_module_cache_ram_33__7 A1=nx35920
+ B0=camera_module_cache_ram_49__7 B1=nx35960
Xcamera_module_cache_reg_ram_33__7 dffr $PINS Q=camera_module_cache_ram_33__7
+ QB=#dummy[1840] D=nx21623 CLK=clk R=rst
Xix21624 mux21_ni $PINS Y=nx21623 A0=camera_module_cache_ram_33__7 A1=nx35600
+ S0=nx35058
Xcamera_module_cache_reg_ram_49__7 dffr $PINS Q=camera_module_cache_ram_49__7
+ QB=#dummy[1841] D=nx21613 CLK=clk R=rst
Xix21614 mux21_ni $PINS Y=nx21613 A0=camera_module_cache_ram_49__7 A1=nx35600
+ S0=nx35054
Xix32379 aoi22 $PINS Y=nx32378 A0=camera_module_cache_ram_65__7 A1=nx36000
+ B0=camera_module_cache_ram_81__7 B1=nx36040
Xcamera_module_cache_reg_ram_65__7 dffr $PINS Q=camera_module_cache_ram_65__7
+ QB=#dummy[1842] D=nx21603 CLK=clk R=rst
Xix21604 mux21_ni $PINS Y=nx21603 A0=camera_module_cache_ram_65__7 A1=nx35600
+ S0=nx35050
Xcamera_module_cache_reg_ram_81__7 dffr $PINS Q=camera_module_cache_ram_81__7
+ QB=#dummy[1843] D=nx21593 CLK=clk R=rst
Xix21594 mux21_ni $PINS Y=nx21593 A0=camera_module_cache_ram_81__7 A1=nx35602
+ S0=nx35046
Xix32387 aoi22 $PINS Y=nx32386 A0=camera_module_cache_ram_113__7 A1=nx36080
+ B0=camera_module_cache_ram_97__7 B1=nx36120
Xcamera_module_cache_reg_ram_113__7 dffr $PINS Q=camera_module_cache_ram_113__7
+ QB=#dummy[1844] D=nx21573 CLK=clk R=rst
Xix21574 mux21_ni $PINS Y=nx21573 A0=camera_module_cache_ram_113__7 A1=nx35602
+ S0=nx35038
Xcamera_module_cache_reg_ram_97__7 dffr $PINS Q=camera_module_cache_ram_97__7
+ QB=#dummy[1845] D=nx21583 CLK=clk R=rst
Xix21584 mux21_ni $PINS Y=nx21583 A0=camera_module_cache_ram_97__7 A1=nx35602
+ S0=nx35042
Xix25113 nand04 $PINS Y=nx25112 A0=nx32395 A1=nx32403 A2=nx32411 A3=nx32419
Xix32396 aoi22 $PINS Y=nx32395 A0=camera_module_cache_ram_129__7 A1=nx36160
+ B0=camera_module_cache_ram_145__7 B1=nx36200
Xcamera_module_cache_reg_ram_129__7 dffr $PINS Q=camera_module_cache_ram_129__7
+ QB=#dummy[1846] D=nx21563 CLK=clk R=rst
Xix21564 mux21_ni $PINS Y=nx21563 A0=camera_module_cache_ram_129__7 A1=nx35602
+ S0=nx35034
Xcamera_module_cache_reg_ram_145__7 dffr $PINS Q=camera_module_cache_ram_145__7
+ QB=#dummy[1847] D=nx21553 CLK=clk R=rst
Xix21554 mux21_ni $PINS Y=nx21553 A0=camera_module_cache_ram_145__7 A1=nx35602
+ S0=nx35030
Xix32404 aoi22 $PINS Y=nx32403 A0=camera_module_cache_ram_177__7 A1=nx36240
+ B0=camera_module_cache_ram_161__7 B1=nx36280
Xcamera_module_cache_reg_ram_177__7 dffr $PINS Q=camera_module_cache_ram_177__7
+ QB=#dummy[1848] D=nx21533 CLK=clk R=rst
Xix21534 mux21_ni $PINS Y=nx21533 A0=camera_module_cache_ram_177__7 A1=nx35602
+ S0=nx35022
Xcamera_module_cache_reg_ram_161__7 dffr $PINS Q=camera_module_cache_ram_161__7
+ QB=#dummy[1849] D=nx21543 CLK=clk R=rst
Xix21544 mux21_ni $PINS Y=nx21543 A0=camera_module_cache_ram_161__7 A1=nx35602
+ S0=nx35026
Xix32412 aoi22 $PINS Y=nx32411 A0=camera_module_cache_ram_193__7 A1=nx36320
+ B0=camera_module_cache_ram_209__7 B1=nx36360
Xcamera_module_cache_reg_ram_193__7 dffr $PINS Q=camera_module_cache_ram_193__7
+ QB=#dummy[1850] D=nx21523 CLK=clk R=rst
Xix21524 mux21_ni $PINS Y=nx21523 A0=camera_module_cache_ram_193__7 A1=nx35604
+ S0=nx35018
Xcamera_module_cache_reg_ram_209__7 dffr $PINS Q=camera_module_cache_ram_209__7
+ QB=#dummy[1851] D=nx21513 CLK=clk R=rst
Xix21514 mux21_ni $PINS Y=nx21513 A0=camera_module_cache_ram_209__7 A1=nx35604
+ S0=nx35014
Xix32420 aoi22 $PINS Y=nx32419 A0=camera_module_cache_ram_225__7 A1=nx36400
+ B0=camera_module_cache_ram_241__7 B1=nx36440
Xcamera_module_cache_reg_ram_225__7 dffr $PINS Q=camera_module_cache_ram_225__7
+ QB=#dummy[1852] D=nx21503 CLK=clk R=rst
Xix21504 mux21_ni $PINS Y=nx21503 A0=camera_module_cache_ram_225__7 A1=nx35604
+ S0=nx35010
Xcamera_module_cache_reg_ram_241__7 dffr $PINS Q=camera_module_cache_ram_241__7
+ QB=#dummy[1853] D=nx21493 CLK=clk R=rst
Xix21494 mux21_ni $PINS Y=nx21493 A0=camera_module_cache_ram_241__7 A1=nx35604
+ S0=nx35006
Xix32428 oai21 $PINS Y=nx32427 A0=nx25026 A1=nx24948 B0=nx37240
Xix25027 nand04 $PINS Y=nx25026 A0=nx32430 A1=nx32438 A2=nx32446 A3=nx32454
Xix32431 aoi22 $PINS Y=nx32430 A0=camera_module_cache_ram_2__7 A1=nx35840
+ B0=camera_module_cache_ram_18__7 B1=nx35880
Xcamera_module_cache_reg_ram_2__7 dffr $PINS Q=camera_module_cache_ram_2__7
+ QB=#dummy[1854] D=nx21483 CLK=clk R=rst
Xix21484 mux21_ni $PINS Y=nx21483 A0=camera_module_cache_ram_2__7 A1=nx35604
+ S0=nx34996
Xcamera_module_cache_reg_ram_18__7 dffr $PINS Q=camera_module_cache_ram_18__7
+ QB=#dummy[1855] D=nx21473 CLK=clk R=rst
Xix21474 mux21_ni $PINS Y=nx21473 A0=camera_module_cache_ram_18__7 A1=nx35604
+ S0=nx34992
Xix32439 aoi22 $PINS Y=nx32438 A0=camera_module_cache_ram_34__7 A1=nx35920
+ B0=camera_module_cache_ram_50__7 B1=nx35960
Xcamera_module_cache_reg_ram_34__7 dffr $PINS Q=camera_module_cache_ram_34__7
+ QB=#dummy[1856] D=nx21463 CLK=clk R=rst
Xix21464 mux21_ni $PINS Y=nx21463 A0=camera_module_cache_ram_34__7 A1=nx35604
+ S0=nx34988
Xcamera_module_cache_reg_ram_50__7 dffr $PINS Q=camera_module_cache_ram_50__7
+ QB=#dummy[1857] D=nx21453 CLK=clk R=rst
Xix21454 mux21_ni $PINS Y=nx21453 A0=camera_module_cache_ram_50__7 A1=nx35606
+ S0=nx34984
Xix32447 aoi22 $PINS Y=nx32446 A0=camera_module_cache_ram_66__7 A1=nx36000
+ B0=camera_module_cache_ram_82__7 B1=nx36040
Xcamera_module_cache_reg_ram_66__7 dffr $PINS Q=camera_module_cache_ram_66__7
+ QB=#dummy[1858] D=nx21443 CLK=clk R=rst
Xix21444 mux21_ni $PINS Y=nx21443 A0=camera_module_cache_ram_66__7 A1=nx35606
+ S0=nx34980
Xcamera_module_cache_reg_ram_82__7 dffr $PINS Q=camera_module_cache_ram_82__7
+ QB=#dummy[1859] D=nx21433 CLK=clk R=rst
Xix21434 mux21_ni $PINS Y=nx21433 A0=camera_module_cache_ram_82__7 A1=nx35606
+ S0=nx34976
Xix32455 aoi22 $PINS Y=nx32454 A0=camera_module_cache_ram_114__7 A1=nx36080
+ B0=camera_module_cache_ram_98__7 B1=nx36120
Xcamera_module_cache_reg_ram_114__7 dffr $PINS Q=camera_module_cache_ram_114__7
+ QB=#dummy[1860] D=nx21413 CLK=clk R=rst
Xix21414 mux21_ni $PINS Y=nx21413 A0=camera_module_cache_ram_114__7 A1=nx35606
+ S0=nx34968
Xcamera_module_cache_reg_ram_98__7 dffr $PINS Q=camera_module_cache_ram_98__7
+ QB=#dummy[1861] D=nx21423 CLK=clk R=rst
Xix21424 mux21_ni $PINS Y=nx21423 A0=camera_module_cache_ram_98__7 A1=nx35606
+ S0=nx34972
Xix24949 nand04 $PINS Y=nx24948 A0=nx32463 A1=nx32471 A2=nx32479 A3=nx32487
Xix32464 aoi22 $PINS Y=nx32463 A0=camera_module_cache_ram_130__7 A1=nx36160
+ B0=camera_module_cache_ram_146__7 B1=nx36200
Xcamera_module_cache_reg_ram_130__7 dffr $PINS Q=camera_module_cache_ram_130__7
+ QB=#dummy[1862] D=nx21403 CLK=clk R=rst
Xix21404 mux21_ni $PINS Y=nx21403 A0=camera_module_cache_ram_130__7 A1=nx35606
+ S0=nx34964
Xcamera_module_cache_reg_ram_146__7 dffr $PINS Q=camera_module_cache_ram_146__7
+ QB=#dummy[1863] D=nx21393 CLK=clk R=rst
Xix21394 mux21_ni $PINS Y=nx21393 A0=camera_module_cache_ram_146__7 A1=nx35606
+ S0=nx34960
Xix32472 aoi22 $PINS Y=nx32471 A0=camera_module_cache_ram_178__7 A1=nx36240
+ B0=camera_module_cache_ram_162__7 B1=nx36280
Xcamera_module_cache_reg_ram_178__7 dffr $PINS Q=camera_module_cache_ram_178__7
+ QB=#dummy[1864] D=nx21373 CLK=clk R=rst
Xix21374 mux21_ni $PINS Y=nx21373 A0=camera_module_cache_ram_178__7 A1=nx35608
+ S0=nx34952
Xcamera_module_cache_reg_ram_162__7 dffr $PINS Q=camera_module_cache_ram_162__7
+ QB=#dummy[1865] D=nx21383 CLK=clk R=rst
Xix21384 mux21_ni $PINS Y=nx21383 A0=camera_module_cache_ram_162__7 A1=nx35608
+ S0=nx34956
Xix32480 aoi22 $PINS Y=nx32479 A0=camera_module_cache_ram_194__7 A1=nx36320
+ B0=camera_module_cache_ram_210__7 B1=nx36360
Xcamera_module_cache_reg_ram_194__7 dffr $PINS Q=camera_module_cache_ram_194__7
+ QB=#dummy[1866] D=nx21363 CLK=clk R=rst
Xix21364 mux21_ni $PINS Y=nx21363 A0=camera_module_cache_ram_194__7 A1=nx35608
+ S0=nx34948
Xcamera_module_cache_reg_ram_210__7 dffr $PINS Q=camera_module_cache_ram_210__7
+ QB=#dummy[1867] D=nx21353 CLK=clk R=rst
Xix21354 mux21_ni $PINS Y=nx21353 A0=camera_module_cache_ram_210__7 A1=nx35608
+ S0=nx34944
Xix32488 aoi22 $PINS Y=nx32487 A0=camera_module_cache_ram_226__7 A1=nx36400
+ B0=camera_module_cache_ram_242__7 B1=nx36440
Xcamera_module_cache_reg_ram_226__7 dffr $PINS Q=camera_module_cache_ram_226__7
+ QB=#dummy[1868] D=nx21343 CLK=clk R=rst
Xix21344 mux21_ni $PINS Y=nx21343 A0=camera_module_cache_ram_226__7 A1=nx35608
+ S0=nx34940
Xcamera_module_cache_reg_ram_242__7 dffr $PINS Q=camera_module_cache_ram_242__7
+ QB=#dummy[1869] D=nx21333 CLK=clk R=rst
Xix21334 mux21_ni $PINS Y=nx21333 A0=camera_module_cache_ram_242__7 A1=nx35608
+ S0=nx34936
Xix32496 oai21 $PINS Y=nx32495 A0=nx24864 A1=nx24786 B0=nx37244
Xix24865 nand04 $PINS Y=nx24864 A0=nx32498 A1=nx32506 A2=nx32514 A3=nx32522
Xix32499 aoi22 $PINS Y=nx32498 A0=camera_module_cache_ram_3__7 A1=nx35842
+ B0=camera_module_cache_ram_19__7 B1=nx35882
Xcamera_module_cache_reg_ram_3__7 dffr $PINS Q=camera_module_cache_ram_3__7
+ QB=#dummy[1870] D=nx21323 CLK=clk R=rst
Xix21324 mux21_ni $PINS Y=nx21323 A0=camera_module_cache_ram_3__7 A1=nx35608
+ S0=nx34926
Xcamera_module_cache_reg_ram_19__7 dffr $PINS Q=camera_module_cache_ram_19__7
+ QB=#dummy[1871] D=nx21313 CLK=clk R=rst
Xix21314 mux21_ni $PINS Y=nx21313 A0=camera_module_cache_ram_19__7 A1=nx35610
+ S0=nx34922
Xix32507 aoi22 $PINS Y=nx32506 A0=camera_module_cache_ram_35__7 A1=nx35922
+ B0=camera_module_cache_ram_51__7 B1=nx35962
Xcamera_module_cache_reg_ram_35__7 dffr $PINS Q=camera_module_cache_ram_35__7
+ QB=#dummy[1872] D=nx21303 CLK=clk R=rst
Xix21304 mux21_ni $PINS Y=nx21303 A0=camera_module_cache_ram_35__7 A1=nx35610
+ S0=nx34918
Xcamera_module_cache_reg_ram_51__7 dffr $PINS Q=camera_module_cache_ram_51__7
+ QB=#dummy[1873] D=nx21293 CLK=clk R=rst
Xix21294 mux21_ni $PINS Y=nx21293 A0=camera_module_cache_ram_51__7 A1=nx35610
+ S0=nx34914
Xix32515 aoi22 $PINS Y=nx32514 A0=camera_module_cache_ram_67__7 A1=nx36002
+ B0=camera_module_cache_ram_83__7 B1=nx36042
Xcamera_module_cache_reg_ram_67__7 dffr $PINS Q=camera_module_cache_ram_67__7
+ QB=#dummy[1874] D=nx21283 CLK=clk R=rst
Xix21284 mux21_ni $PINS Y=nx21283 A0=camera_module_cache_ram_67__7 A1=nx35610
+ S0=nx34910
Xcamera_module_cache_reg_ram_83__7 dffr $PINS Q=camera_module_cache_ram_83__7
+ QB=#dummy[1875] D=nx21273 CLK=clk R=rst
Xix21274 mux21_ni $PINS Y=nx21273 A0=camera_module_cache_ram_83__7 A1=nx35610
+ S0=nx34906
Xix32523 aoi22 $PINS Y=nx32522 A0=camera_module_cache_ram_115__7 A1=nx36082
+ B0=camera_module_cache_ram_99__7 B1=nx36122
Xcamera_module_cache_reg_ram_115__7 dffr $PINS Q=camera_module_cache_ram_115__7
+ QB=#dummy[1876] D=nx21253 CLK=clk R=rst
Xix21254 mux21_ni $PINS Y=nx21253 A0=camera_module_cache_ram_115__7 A1=nx35610
+ S0=nx34898
Xcamera_module_cache_reg_ram_99__7 dffr $PINS Q=camera_module_cache_ram_99__7
+ QB=#dummy[1877] D=nx21263 CLK=clk R=rst
Xix21264 mux21_ni $PINS Y=nx21263 A0=camera_module_cache_ram_99__7 A1=nx35610
+ S0=nx34902
Xix24787 nand04 $PINS Y=nx24786 A0=nx32531 A1=nx32539 A2=nx32547 A3=nx32555
Xix32532 aoi22 $PINS Y=nx32531 A0=camera_module_cache_ram_131__7 A1=nx36162
+ B0=camera_module_cache_ram_147__7 B1=nx36202
Xcamera_module_cache_reg_ram_131__7 dffr $PINS Q=camera_module_cache_ram_131__7
+ QB=#dummy[1878] D=nx21243 CLK=clk R=rst
Xix21244 mux21_ni $PINS Y=nx21243 A0=camera_module_cache_ram_131__7 A1=nx35612
+ S0=nx34894
Xcamera_module_cache_reg_ram_147__7 dffr $PINS Q=camera_module_cache_ram_147__7
+ QB=#dummy[1879] D=nx21233 CLK=clk R=rst
Xix21234 mux21_ni $PINS Y=nx21233 A0=camera_module_cache_ram_147__7 A1=nx35612
+ S0=nx34890
Xix32540 aoi22 $PINS Y=nx32539 A0=camera_module_cache_ram_179__7 A1=nx36242
+ B0=camera_module_cache_ram_163__7 B1=nx36282
Xcamera_module_cache_reg_ram_179__7 dffr $PINS Q=camera_module_cache_ram_179__7
+ QB=#dummy[1880] D=nx21213 CLK=clk R=rst
Xix21214 mux21_ni $PINS Y=nx21213 A0=camera_module_cache_ram_179__7 A1=nx35612
+ S0=nx34882
Xcamera_module_cache_reg_ram_163__7 dffr $PINS Q=camera_module_cache_ram_163__7
+ QB=#dummy[1881] D=nx21223 CLK=clk R=rst
Xix21224 mux21_ni $PINS Y=nx21223 A0=camera_module_cache_ram_163__7 A1=nx35612
+ S0=nx34886
Xix32548 aoi22 $PINS Y=nx32547 A0=camera_module_cache_ram_195__7 A1=nx36322
+ B0=camera_module_cache_ram_211__7 B1=nx36362
Xcamera_module_cache_reg_ram_195__7 dffr $PINS Q=camera_module_cache_ram_195__7
+ QB=#dummy[1882] D=nx21203 CLK=clk R=rst
Xix21204 mux21_ni $PINS Y=nx21203 A0=camera_module_cache_ram_195__7 A1=nx35612
+ S0=nx34878
Xcamera_module_cache_reg_ram_211__7 dffr $PINS Q=camera_module_cache_ram_211__7
+ QB=#dummy[1883] D=nx21193 CLK=clk R=rst
Xix21194 mux21_ni $PINS Y=nx21193 A0=camera_module_cache_ram_211__7 A1=nx35612
+ S0=nx34874
Xix32556 aoi22 $PINS Y=nx32555 A0=camera_module_cache_ram_227__7 A1=nx36402
+ B0=camera_module_cache_ram_243__7 B1=nx36442
Xcamera_module_cache_reg_ram_227__7 dffr $PINS Q=camera_module_cache_ram_227__7
+ QB=#dummy[1884] D=nx21183 CLK=clk R=rst
Xix21184 mux21_ni $PINS Y=nx21183 A0=camera_module_cache_ram_227__7 A1=nx35612
+ S0=nx34870
Xcamera_module_cache_reg_ram_243__7 dffr $PINS Q=camera_module_cache_ram_243__7
+ QB=#dummy[1885] D=nx21173 CLK=clk R=rst
Xix21174 mux21_ni $PINS Y=nx21173 A0=camera_module_cache_ram_243__7 A1=nx35614
+ S0=nx34866
Xix24709 nand04 $PINS Y=nx24708 A0=nx32564 A1=nx32632 A2=nx32700 A3=nx32768
Xix32565 oai21 $PINS Y=nx32564 A0=nx24698 A1=nx24620 B0=nx37248
Xix24699 nand04 $PINS Y=nx24698 A0=nx32567 A1=nx32575 A2=nx32583 A3=nx32591
Xix32568 aoi22 $PINS Y=nx32567 A0=camera_module_cache_ram_4__7 A1=nx35842
+ B0=camera_module_cache_ram_20__7 B1=nx35882
Xcamera_module_cache_reg_ram_4__7 dffr $PINS Q=camera_module_cache_ram_4__7
+ QB=#dummy[1886] D=nx21163 CLK=clk R=rst
Xix21164 mux21_ni $PINS Y=nx21163 A0=camera_module_cache_ram_4__7 A1=nx35614
+ S0=nx34856
Xcamera_module_cache_reg_ram_20__7 dffr $PINS Q=camera_module_cache_ram_20__7
+ QB=#dummy[1887] D=nx21153 CLK=clk R=rst
Xix21154 mux21_ni $PINS Y=nx21153 A0=camera_module_cache_ram_20__7 A1=nx35614
+ S0=nx34852
Xix32576 aoi22 $PINS Y=nx32575 A0=camera_module_cache_ram_36__7 A1=nx35922
+ B0=camera_module_cache_ram_52__7 B1=nx35962
Xcamera_module_cache_reg_ram_36__7 dffr $PINS Q=camera_module_cache_ram_36__7
+ QB=#dummy[1888] D=nx21143 CLK=clk R=rst
Xix21144 mux21_ni $PINS Y=nx21143 A0=camera_module_cache_ram_36__7 A1=nx35614
+ S0=nx34848
Xcamera_module_cache_reg_ram_52__7 dffr $PINS Q=camera_module_cache_ram_52__7
+ QB=#dummy[1889] D=nx21133 CLK=clk R=rst
Xix21134 mux21_ni $PINS Y=nx21133 A0=camera_module_cache_ram_52__7 A1=nx35614
+ S0=nx34844
Xix32584 aoi22 $PINS Y=nx32583 A0=camera_module_cache_ram_68__7 A1=nx36002
+ B0=camera_module_cache_ram_84__7 B1=nx36042
Xcamera_module_cache_reg_ram_68__7 dffr $PINS Q=camera_module_cache_ram_68__7
+ QB=#dummy[1890] D=nx21123 CLK=clk R=rst
Xix21124 mux21_ni $PINS Y=nx21123 A0=camera_module_cache_ram_68__7 A1=nx35614
+ S0=nx34840
Xcamera_module_cache_reg_ram_84__7 dffr $PINS Q=camera_module_cache_ram_84__7
+ QB=#dummy[1891] D=nx21113 CLK=clk R=rst
Xix21114 mux21_ni $PINS Y=nx21113 A0=camera_module_cache_ram_84__7 A1=nx35614
+ S0=nx34836
Xix32592 aoi22 $PINS Y=nx32591 A0=camera_module_cache_ram_116__7 A1=nx36082
+ B0=camera_module_cache_ram_100__7 B1=nx36122
Xcamera_module_cache_reg_ram_116__7 dffr $PINS Q=camera_module_cache_ram_116__7
+ QB=#dummy[1892] D=nx21093 CLK=clk R=rst
Xix21094 mux21_ni $PINS Y=nx21093 A0=camera_module_cache_ram_116__7 A1=nx35616
+ S0=nx34828
Xcamera_module_cache_reg_ram_100__7 dffr $PINS Q=camera_module_cache_ram_100__7
+ QB=#dummy[1893] D=nx21103 CLK=clk R=rst
Xix21104 mux21_ni $PINS Y=nx21103 A0=camera_module_cache_ram_100__7 A1=nx35616
+ S0=nx34832
Xix24621 nand04 $PINS Y=nx24620 A0=nx32600 A1=nx32608 A2=nx32616 A3=nx32624
Xix32601 aoi22 $PINS Y=nx32600 A0=camera_module_cache_ram_132__7 A1=nx36162
+ B0=camera_module_cache_ram_148__7 B1=nx36202
Xcamera_module_cache_reg_ram_132__7 dffr $PINS Q=camera_module_cache_ram_132__7
+ QB=#dummy[1894] D=nx21083 CLK=clk R=rst
Xix21084 mux21_ni $PINS Y=nx21083 A0=camera_module_cache_ram_132__7 A1=nx35616
+ S0=nx34824
Xcamera_module_cache_reg_ram_148__7 dffr $PINS Q=camera_module_cache_ram_148__7
+ QB=#dummy[1895] D=nx21073 CLK=clk R=rst
Xix21074 mux21_ni $PINS Y=nx21073 A0=camera_module_cache_ram_148__7 A1=nx35616
+ S0=nx34820
Xix32609 aoi22 $PINS Y=nx32608 A0=camera_module_cache_ram_180__7 A1=nx36242
+ B0=camera_module_cache_ram_164__7 B1=nx36282
Xcamera_module_cache_reg_ram_180__7 dffr $PINS Q=camera_module_cache_ram_180__7
+ QB=#dummy[1896] D=nx21053 CLK=clk R=rst
Xix21054 mux21_ni $PINS Y=nx21053 A0=camera_module_cache_ram_180__7 A1=nx35616
+ S0=nx34812
Xcamera_module_cache_reg_ram_164__7 dffr $PINS Q=camera_module_cache_ram_164__7
+ QB=#dummy[1897] D=nx21063 CLK=clk R=rst
Xix21064 mux21_ni $PINS Y=nx21063 A0=camera_module_cache_ram_164__7 A1=nx35616
+ S0=nx34816
Xix32617 aoi22 $PINS Y=nx32616 A0=camera_module_cache_ram_196__7 A1=nx36322
+ B0=camera_module_cache_ram_212__7 B1=nx36362
Xcamera_module_cache_reg_ram_196__7 dffr $PINS Q=camera_module_cache_ram_196__7
+ QB=#dummy[1898] D=nx21043 CLK=clk R=rst
Xix21044 mux21_ni $PINS Y=nx21043 A0=camera_module_cache_ram_196__7 A1=nx35616
+ S0=nx34808
Xcamera_module_cache_reg_ram_212__7 dffr $PINS Q=camera_module_cache_ram_212__7
+ QB=#dummy[1899] D=nx21033 CLK=clk R=rst
Xix21034 mux21_ni $PINS Y=nx21033 A0=camera_module_cache_ram_212__7 A1=nx35618
+ S0=nx34804
Xix32625 aoi22 $PINS Y=nx32624 A0=camera_module_cache_ram_228__7 A1=nx36402
+ B0=camera_module_cache_ram_244__7 B1=nx36442
Xcamera_module_cache_reg_ram_228__7 dffr $PINS Q=camera_module_cache_ram_228__7
+ QB=#dummy[1900] D=nx21023 CLK=clk R=rst
Xix21024 mux21_ni $PINS Y=nx21023 A0=camera_module_cache_ram_228__7 A1=nx35618
+ S0=nx34800
Xcamera_module_cache_reg_ram_244__7 dffr $PINS Q=camera_module_cache_ram_244__7
+ QB=#dummy[1901] D=nx21013 CLK=clk R=rst
Xix21014 mux21_ni $PINS Y=nx21013 A0=camera_module_cache_ram_244__7 A1=nx35618
+ S0=nx34796
Xix32633 oai21 $PINS Y=nx32632 A0=nx24536 A1=nx24458 B0=nx37252
Xix24537 nand04 $PINS Y=nx24536 A0=nx32635 A1=nx32643 A2=nx32651 A3=nx32659
Xix32636 aoi22 $PINS Y=nx32635 A0=camera_module_cache_ram_5__7 A1=nx35842
+ B0=camera_module_cache_ram_21__7 B1=nx35882
Xcamera_module_cache_reg_ram_5__7 dffr $PINS Q=camera_module_cache_ram_5__7
+ QB=#dummy[1902] D=nx21003 CLK=clk R=rst
Xix21004 mux21_ni $PINS Y=nx21003 A0=camera_module_cache_ram_5__7 A1=nx35618
+ S0=nx34786
Xcamera_module_cache_reg_ram_21__7 dffr $PINS Q=camera_module_cache_ram_21__7
+ QB=#dummy[1903] D=nx20993 CLK=clk R=rst
Xix20994 mux21_ni $PINS Y=nx20993 A0=camera_module_cache_ram_21__7 A1=nx35618
+ S0=nx34782
Xix32644 aoi22 $PINS Y=nx32643 A0=camera_module_cache_ram_37__7 A1=nx35922
+ B0=camera_module_cache_ram_53__7 B1=nx35962
Xcamera_module_cache_reg_ram_37__7 dffr $PINS Q=camera_module_cache_ram_37__7
+ QB=#dummy[1904] D=nx20983 CLK=clk R=rst
Xix20984 mux21_ni $PINS Y=nx20983 A0=camera_module_cache_ram_37__7 A1=nx35618
+ S0=nx34778
Xcamera_module_cache_reg_ram_53__7 dffr $PINS Q=camera_module_cache_ram_53__7
+ QB=#dummy[1905] D=nx20973 CLK=clk R=rst
Xix20974 mux21_ni $PINS Y=nx20973 A0=camera_module_cache_ram_53__7 A1=nx35618
+ S0=nx34774
Xix32652 aoi22 $PINS Y=nx32651 A0=camera_module_cache_ram_69__7 A1=nx36002
+ B0=camera_module_cache_ram_85__7 B1=nx36042
Xcamera_module_cache_reg_ram_69__7 dffr $PINS Q=camera_module_cache_ram_69__7
+ QB=#dummy[1906] D=nx20963 CLK=clk R=rst
Xix20964 mux21_ni $PINS Y=nx20963 A0=camera_module_cache_ram_69__7 A1=nx35620
+ S0=nx34770
Xcamera_module_cache_reg_ram_85__7 dffr $PINS Q=camera_module_cache_ram_85__7
+ QB=#dummy[1907] D=nx20953 CLK=clk R=rst
Xix20954 mux21_ni $PINS Y=nx20953 A0=camera_module_cache_ram_85__7 A1=nx35620
+ S0=nx34766
Xix32660 aoi22 $PINS Y=nx32659 A0=camera_module_cache_ram_117__7 A1=nx36082
+ B0=camera_module_cache_ram_101__7 B1=nx36122
Xcamera_module_cache_reg_ram_117__7 dffr $PINS Q=camera_module_cache_ram_117__7
+ QB=#dummy[1908] D=nx20933 CLK=clk R=rst
Xix20934 mux21_ni $PINS Y=nx20933 A0=camera_module_cache_ram_117__7 A1=nx35620
+ S0=nx34758
Xcamera_module_cache_reg_ram_101__7 dffr $PINS Q=camera_module_cache_ram_101__7
+ QB=#dummy[1909] D=nx20943 CLK=clk R=rst
Xix20944 mux21_ni $PINS Y=nx20943 A0=camera_module_cache_ram_101__7 A1=nx35620
+ S0=nx34762
Xix24459 nand04 $PINS Y=nx24458 A0=nx32668 A1=nx32676 A2=nx32684 A3=nx32692
Xix32669 aoi22 $PINS Y=nx32668 A0=camera_module_cache_ram_133__7 A1=nx36162
+ B0=camera_module_cache_ram_149__7 B1=nx36202
Xcamera_module_cache_reg_ram_133__7 dffr $PINS Q=camera_module_cache_ram_133__7
+ QB=#dummy[1910] D=nx20923 CLK=clk R=rst
Xix20924 mux21_ni $PINS Y=nx20923 A0=camera_module_cache_ram_133__7 A1=nx35620
+ S0=nx34754
Xcamera_module_cache_reg_ram_149__7 dffr $PINS Q=camera_module_cache_ram_149__7
+ QB=#dummy[1911] D=nx20913 CLK=clk R=rst
Xix20914 mux21_ni $PINS Y=nx20913 A0=camera_module_cache_ram_149__7 A1=nx35620
+ S0=nx34750
Xix32677 aoi22 $PINS Y=nx32676 A0=camera_module_cache_ram_181__7 A1=nx36242
+ B0=camera_module_cache_ram_165__7 B1=nx36282
Xcamera_module_cache_reg_ram_181__7 dffr $PINS Q=camera_module_cache_ram_181__7
+ QB=#dummy[1912] D=nx20893 CLK=clk R=rst
Xix20894 mux21_ni $PINS Y=nx20893 A0=camera_module_cache_ram_181__7 A1=nx35620
+ S0=nx34742
Xcamera_module_cache_reg_ram_165__7 dffr $PINS Q=camera_module_cache_ram_165__7
+ QB=#dummy[1913] D=nx20903 CLK=clk R=rst
Xix20904 mux21_ni $PINS Y=nx20903 A0=camera_module_cache_ram_165__7 A1=nx35622
+ S0=nx34746
Xix32685 aoi22 $PINS Y=nx32684 A0=camera_module_cache_ram_197__7 A1=nx36322
+ B0=camera_module_cache_ram_213__7 B1=nx36362
Xcamera_module_cache_reg_ram_197__7 dffr $PINS Q=camera_module_cache_ram_197__7
+ QB=#dummy[1914] D=nx20883 CLK=clk R=rst
Xix20884 mux21_ni $PINS Y=nx20883 A0=camera_module_cache_ram_197__7 A1=nx35622
+ S0=nx34738
Xcamera_module_cache_reg_ram_213__7 dffr $PINS Q=camera_module_cache_ram_213__7
+ QB=#dummy[1915] D=nx20873 CLK=clk R=rst
Xix20874 mux21_ni $PINS Y=nx20873 A0=camera_module_cache_ram_213__7 A1=nx35622
+ S0=nx34734
Xix32693 aoi22 $PINS Y=nx32692 A0=camera_module_cache_ram_229__7 A1=nx36402
+ B0=camera_module_cache_ram_245__7 B1=nx36442
Xcamera_module_cache_reg_ram_229__7 dffr $PINS Q=camera_module_cache_ram_229__7
+ QB=#dummy[1916] D=nx20863 CLK=clk R=rst
Xix20864 mux21_ni $PINS Y=nx20863 A0=camera_module_cache_ram_229__7 A1=nx35622
+ S0=nx34730
Xcamera_module_cache_reg_ram_245__7 dffr $PINS Q=camera_module_cache_ram_245__7
+ QB=#dummy[1917] D=nx20853 CLK=clk R=rst
Xix20854 mux21_ni $PINS Y=nx20853 A0=camera_module_cache_ram_245__7 A1=nx35622
+ S0=nx34726
Xix32701 oai21 $PINS Y=nx32700 A0=nx24372 A1=nx24294 B0=nx37256
Xix24373 nand04 $PINS Y=nx24372 A0=nx32703 A1=nx32711 A2=nx32719 A3=nx32727
Xix32704 aoi22 $PINS Y=nx32703 A0=camera_module_cache_ram_6__7 A1=nx35842
+ B0=camera_module_cache_ram_22__7 B1=nx35882
Xcamera_module_cache_reg_ram_6__7 dffr $PINS Q=camera_module_cache_ram_6__7
+ QB=#dummy[1918] D=nx20843 CLK=clk R=rst
Xix20844 mux21_ni $PINS Y=nx20843 A0=camera_module_cache_ram_6__7 A1=nx35622
+ S0=nx34716
Xcamera_module_cache_reg_ram_22__7 dffr $PINS Q=camera_module_cache_ram_22__7
+ QB=#dummy[1919] D=nx20833 CLK=clk R=rst
Xix20834 mux21_ni $PINS Y=nx20833 A0=camera_module_cache_ram_22__7 A1=nx35622
+ S0=nx34712
Xix32712 aoi22 $PINS Y=nx32711 A0=camera_module_cache_ram_38__7 A1=nx35922
+ B0=camera_module_cache_ram_54__7 B1=nx35962
Xcamera_module_cache_reg_ram_38__7 dffr $PINS Q=camera_module_cache_ram_38__7
+ QB=#dummy[1920] D=nx20823 CLK=clk R=rst
Xix20824 mux21_ni $PINS Y=nx20823 A0=camera_module_cache_ram_38__7 A1=nx35624
+ S0=nx34708
Xcamera_module_cache_reg_ram_54__7 dffr $PINS Q=camera_module_cache_ram_54__7
+ QB=#dummy[1921] D=nx20813 CLK=clk R=rst
Xix20814 mux21_ni $PINS Y=nx20813 A0=camera_module_cache_ram_54__7 A1=nx35624
+ S0=nx34704
Xix32720 aoi22 $PINS Y=nx32719 A0=camera_module_cache_ram_70__7 A1=nx36002
+ B0=camera_module_cache_ram_86__7 B1=nx36042
Xcamera_module_cache_reg_ram_70__7 dffr $PINS Q=camera_module_cache_ram_70__7
+ QB=#dummy[1922] D=nx20803 CLK=clk R=rst
Xix20804 mux21_ni $PINS Y=nx20803 A0=camera_module_cache_ram_70__7 A1=nx35624
+ S0=nx34700
Xcamera_module_cache_reg_ram_86__7 dffr $PINS Q=camera_module_cache_ram_86__7
+ QB=#dummy[1923] D=nx20793 CLK=clk R=rst
Xix20794 mux21_ni $PINS Y=nx20793 A0=camera_module_cache_ram_86__7 A1=nx35624
+ S0=nx34696
Xix32728 aoi22 $PINS Y=nx32727 A0=camera_module_cache_ram_118__7 A1=nx36082
+ B0=camera_module_cache_ram_102__7 B1=nx36122
Xcamera_module_cache_reg_ram_118__7 dffr $PINS Q=camera_module_cache_ram_118__7
+ QB=#dummy[1924] D=nx20773 CLK=clk R=rst
Xix20774 mux21_ni $PINS Y=nx20773 A0=camera_module_cache_ram_118__7 A1=nx35624
+ S0=nx34688
Xcamera_module_cache_reg_ram_102__7 dffr $PINS Q=camera_module_cache_ram_102__7
+ QB=#dummy[1925] D=nx20783 CLK=clk R=rst
Xix20784 mux21_ni $PINS Y=nx20783 A0=camera_module_cache_ram_102__7 A1=nx35624
+ S0=nx34692
Xix24295 nand04 $PINS Y=nx24294 A0=nx32736 A1=nx32744 A2=nx32752 A3=nx32760
Xix32737 aoi22 $PINS Y=nx32736 A0=camera_module_cache_ram_134__7 A1=nx36162
+ B0=camera_module_cache_ram_150__7 B1=nx36202
Xcamera_module_cache_reg_ram_134__7 dffr $PINS Q=camera_module_cache_ram_134__7
+ QB=#dummy[1926] D=nx20763 CLK=clk R=rst
Xix20764 mux21_ni $PINS Y=nx20763 A0=camera_module_cache_ram_134__7 A1=nx35624
+ S0=nx34684
Xcamera_module_cache_reg_ram_150__7 dffr $PINS Q=camera_module_cache_ram_150__7
+ QB=#dummy[1927] D=nx20753 CLK=clk R=rst
Xix20754 mux21_ni $PINS Y=nx20753 A0=camera_module_cache_ram_150__7 A1=nx35626
+ S0=nx34680
Xix32745 aoi22 $PINS Y=nx32744 A0=camera_module_cache_ram_182__7 A1=nx36242
+ B0=camera_module_cache_ram_166__7 B1=nx36282
Xcamera_module_cache_reg_ram_182__7 dffr $PINS Q=camera_module_cache_ram_182__7
+ QB=#dummy[1928] D=nx20733 CLK=clk R=rst
Xix20734 mux21_ni $PINS Y=nx20733 A0=camera_module_cache_ram_182__7 A1=nx35626
+ S0=nx34672
Xcamera_module_cache_reg_ram_166__7 dffr $PINS Q=camera_module_cache_ram_166__7
+ QB=#dummy[1929] D=nx20743 CLK=clk R=rst
Xix20744 mux21_ni $PINS Y=nx20743 A0=camera_module_cache_ram_166__7 A1=nx35626
+ S0=nx34676
Xix32753 aoi22 $PINS Y=nx32752 A0=camera_module_cache_ram_198__7 A1=nx36322
+ B0=camera_module_cache_ram_214__7 B1=nx36362
Xcamera_module_cache_reg_ram_198__7 dffr $PINS Q=camera_module_cache_ram_198__7
+ QB=#dummy[1930] D=nx20723 CLK=clk R=rst
Xix20724 mux21_ni $PINS Y=nx20723 A0=camera_module_cache_ram_198__7 A1=nx35626
+ S0=nx34668
Xcamera_module_cache_reg_ram_214__7 dffr $PINS Q=camera_module_cache_ram_214__7
+ QB=#dummy[1931] D=nx20713 CLK=clk R=rst
Xix20714 mux21_ni $PINS Y=nx20713 A0=camera_module_cache_ram_214__7 A1=nx35626
+ S0=nx34664
Xix32761 aoi22 $PINS Y=nx32760 A0=camera_module_cache_ram_230__7 A1=nx36402
+ B0=camera_module_cache_ram_246__7 B1=nx36442
Xcamera_module_cache_reg_ram_230__7 dffr $PINS Q=camera_module_cache_ram_230__7
+ QB=#dummy[1932] D=nx20703 CLK=clk R=rst
Xix20704 mux21_ni $PINS Y=nx20703 A0=camera_module_cache_ram_230__7 A1=nx35626
+ S0=nx34660
Xcamera_module_cache_reg_ram_246__7 dffr $PINS Q=camera_module_cache_ram_246__7
+ QB=#dummy[1933] D=nx20693 CLK=clk R=rst
Xix20694 mux21_ni $PINS Y=nx20693 A0=camera_module_cache_ram_246__7 A1=nx35626
+ S0=nx34656
Xix32769 oai21 $PINS Y=nx32768 A0=nx24210 A1=nx24132 B0=nx37260
Xix24211 nand04 $PINS Y=nx24210 A0=nx32771 A1=nx32779 A2=nx32787 A3=nx32795
Xix32772 aoi22 $PINS Y=nx32771 A0=camera_module_cache_ram_7__7 A1=nx35842
+ B0=camera_module_cache_ram_23__7 B1=nx35882
Xcamera_module_cache_reg_ram_7__7 dffr $PINS Q=camera_module_cache_ram_7__7
+ QB=#dummy[1934] D=nx20683 CLK=clk R=rst
Xix20684 mux21_ni $PINS Y=nx20683 A0=camera_module_cache_ram_7__7 A1=nx35628
+ S0=nx34646
Xcamera_module_cache_reg_ram_23__7 dffr $PINS Q=camera_module_cache_ram_23__7
+ QB=#dummy[1935] D=nx20673 CLK=clk R=rst
Xix20674 mux21_ni $PINS Y=nx20673 A0=camera_module_cache_ram_23__7 A1=nx35628
+ S0=nx34642
Xix32780 aoi22 $PINS Y=nx32779 A0=camera_module_cache_ram_39__7 A1=nx35922
+ B0=camera_module_cache_ram_55__7 B1=nx35962
Xcamera_module_cache_reg_ram_39__7 dffr $PINS Q=camera_module_cache_ram_39__7
+ QB=#dummy[1936] D=nx20663 CLK=clk R=rst
Xix20664 mux21_ni $PINS Y=nx20663 A0=camera_module_cache_ram_39__7 A1=nx35628
+ S0=nx34638
Xcamera_module_cache_reg_ram_55__7 dffr $PINS Q=camera_module_cache_ram_55__7
+ QB=#dummy[1937] D=nx20653 CLK=clk R=rst
Xix20654 mux21_ni $PINS Y=nx20653 A0=camera_module_cache_ram_55__7 A1=nx35628
+ S0=nx34634
Xix32788 aoi22 $PINS Y=nx32787 A0=camera_module_cache_ram_71__7 A1=nx36002
+ B0=camera_module_cache_ram_87__7 B1=nx36042
Xcamera_module_cache_reg_ram_71__7 dffr $PINS Q=camera_module_cache_ram_71__7
+ QB=#dummy[1938] D=nx20643 CLK=clk R=rst
Xix20644 mux21_ni $PINS Y=nx20643 A0=camera_module_cache_ram_71__7 A1=nx35628
+ S0=nx34630
Xcamera_module_cache_reg_ram_87__7 dffr $PINS Q=camera_module_cache_ram_87__7
+ QB=#dummy[1939] D=nx20633 CLK=clk R=rst
Xix20634 mux21_ni $PINS Y=nx20633 A0=camera_module_cache_ram_87__7 A1=nx35628
+ S0=nx34626
Xix32796 aoi22 $PINS Y=nx32795 A0=camera_module_cache_ram_119__7 A1=nx36082
+ B0=camera_module_cache_ram_103__7 B1=nx36122
Xcamera_module_cache_reg_ram_119__7 dffr $PINS Q=camera_module_cache_ram_119__7
+ QB=#dummy[1940] D=nx20613 CLK=clk R=rst
Xix20614 mux21_ni $PINS Y=nx20613 A0=camera_module_cache_ram_119__7 A1=nx35628
+ S0=nx34618
Xcamera_module_cache_reg_ram_103__7 dffr $PINS Q=camera_module_cache_ram_103__7
+ QB=#dummy[1941] D=nx20623 CLK=clk R=rst
Xix20624 mux21_ni $PINS Y=nx20623 A0=camera_module_cache_ram_103__7 A1=nx35630
+ S0=nx34622
Xix24133 nand04 $PINS Y=nx24132 A0=nx32804 A1=nx32812 A2=nx32820 A3=nx32828
Xix32805 aoi22 $PINS Y=nx32804 A0=camera_module_cache_ram_135__7 A1=nx36162
+ B0=camera_module_cache_ram_151__7 B1=nx36202
Xcamera_module_cache_reg_ram_135__7 dffr $PINS Q=camera_module_cache_ram_135__7
+ QB=#dummy[1942] D=nx20603 CLK=clk R=rst
Xix20604 mux21_ni $PINS Y=nx20603 A0=camera_module_cache_ram_135__7 A1=nx35630
+ S0=nx34614
Xcamera_module_cache_reg_ram_151__7 dffr $PINS Q=camera_module_cache_ram_151__7
+ QB=#dummy[1943] D=nx20593 CLK=clk R=rst
Xix20594 mux21_ni $PINS Y=nx20593 A0=camera_module_cache_ram_151__7 A1=nx35630
+ S0=nx34610
Xix32813 aoi22 $PINS Y=nx32812 A0=camera_module_cache_ram_183__7 A1=nx36242
+ B0=camera_module_cache_ram_167__7 B1=nx36282
Xcamera_module_cache_reg_ram_183__7 dffr $PINS Q=camera_module_cache_ram_183__7
+ QB=#dummy[1944] D=nx20573 CLK=clk R=rst
Xix20574 mux21_ni $PINS Y=nx20573 A0=camera_module_cache_ram_183__7 A1=nx35630
+ S0=nx34602
Xcamera_module_cache_reg_ram_167__7 dffr $PINS Q=camera_module_cache_ram_167__7
+ QB=#dummy[1945] D=nx20583 CLK=clk R=rst
Xix20584 mux21_ni $PINS Y=nx20583 A0=camera_module_cache_ram_167__7 A1=nx35630
+ S0=nx34606
Xix32821 aoi22 $PINS Y=nx32820 A0=camera_module_cache_ram_199__7 A1=nx36322
+ B0=camera_module_cache_ram_215__7 B1=nx36362
Xcamera_module_cache_reg_ram_199__7 dffr $PINS Q=camera_module_cache_ram_199__7
+ QB=#dummy[1946] D=nx20563 CLK=clk R=rst
Xix20564 mux21_ni $PINS Y=nx20563 A0=camera_module_cache_ram_199__7 A1=nx35630
+ S0=nx34598
Xcamera_module_cache_reg_ram_215__7 dffr $PINS Q=camera_module_cache_ram_215__7
+ QB=#dummy[1947] D=nx20553 CLK=clk R=rst
Xix20554 mux21_ni $PINS Y=nx20553 A0=camera_module_cache_ram_215__7 A1=nx35630
+ S0=nx34594
Xix32829 aoi22 $PINS Y=nx32828 A0=camera_module_cache_ram_231__7 A1=nx36402
+ B0=camera_module_cache_ram_247__7 B1=nx36442
Xcamera_module_cache_reg_ram_231__7 dffr $PINS Q=camera_module_cache_ram_231__7
+ QB=#dummy[1948] D=nx20543 CLK=clk R=rst
Xix20544 mux21_ni $PINS Y=nx20543 A0=camera_module_cache_ram_231__7 A1=nx35632
+ S0=nx34590
Xcamera_module_cache_reg_ram_247__7 dffr $PINS Q=camera_module_cache_ram_247__7
+ QB=#dummy[1949] D=nx20533 CLK=clk R=rst
Xix20534 mux21_ni $PINS Y=nx20533 A0=camera_module_cache_ram_247__7 A1=nx35632
+ S0=nx34586
Xix24053 nand04 $PINS Y=nx24052 A0=nx32837 A1=nx32905 A2=nx32973 A3=nx33041
Xix32838 oai21 $PINS Y=nx32837 A0=nx24042 A1=nx23964 B0=nx37264
Xix24043 nand04 $PINS Y=nx24042 A0=nx32840 A1=nx32848 A2=nx32856 A3=nx32864
Xix32841 aoi22 $PINS Y=nx32840 A0=camera_module_cache_ram_8__7 A1=nx35842
+ B0=camera_module_cache_ram_24__7 B1=nx35882
Xcamera_module_cache_reg_ram_8__7 dffr $PINS Q=camera_module_cache_ram_8__7
+ QB=#dummy[1950] D=nx20523 CLK=clk R=rst
Xix20524 mux21_ni $PINS Y=nx20523 A0=camera_module_cache_ram_8__7 A1=nx35632
+ S0=nx34576
Xcamera_module_cache_reg_ram_24__7 dffr $PINS Q=camera_module_cache_ram_24__7
+ QB=#dummy[1951] D=nx20513 CLK=clk R=rst
Xix20514 mux21_ni $PINS Y=nx20513 A0=camera_module_cache_ram_24__7 A1=nx35632
+ S0=nx34572
Xix32849 aoi22 $PINS Y=nx32848 A0=camera_module_cache_ram_40__7 A1=nx35922
+ B0=camera_module_cache_ram_56__7 B1=nx35962
Xcamera_module_cache_reg_ram_40__7 dffr $PINS Q=camera_module_cache_ram_40__7
+ QB=#dummy[1952] D=nx20503 CLK=clk R=rst
Xix20504 mux21_ni $PINS Y=nx20503 A0=camera_module_cache_ram_40__7 A1=nx35632
+ S0=nx34568
Xcamera_module_cache_reg_ram_56__7 dffr $PINS Q=camera_module_cache_ram_56__7
+ QB=#dummy[1953] D=nx20493 CLK=clk R=rst
Xix20494 mux21_ni $PINS Y=nx20493 A0=camera_module_cache_ram_56__7 A1=nx35632
+ S0=nx34564
Xix32857 aoi22 $PINS Y=nx32856 A0=camera_module_cache_ram_72__7 A1=nx36002
+ B0=camera_module_cache_ram_88__7 B1=nx36042
Xcamera_module_cache_reg_ram_72__7 dffr $PINS Q=camera_module_cache_ram_72__7
+ QB=#dummy[1954] D=nx20483 CLK=clk R=rst
Xix20484 mux21_ni $PINS Y=nx20483 A0=camera_module_cache_ram_72__7 A1=nx35632
+ S0=nx34560
Xcamera_module_cache_reg_ram_88__7 dffr $PINS Q=camera_module_cache_ram_88__7
+ QB=#dummy[1955] D=nx20473 CLK=clk R=rst
Xix20474 mux21_ni $PINS Y=nx20473 A0=camera_module_cache_ram_88__7 A1=nx35634
+ S0=nx34556
Xix32865 aoi22 $PINS Y=nx32864 A0=camera_module_cache_ram_120__7 A1=nx36082
+ B0=camera_module_cache_ram_104__7 B1=nx36122
Xcamera_module_cache_reg_ram_120__7 dffr $PINS Q=camera_module_cache_ram_120__7
+ QB=#dummy[1956] D=nx20453 CLK=clk R=rst
Xix20454 mux21_ni $PINS Y=nx20453 A0=camera_module_cache_ram_120__7 A1=nx35634
+ S0=nx34548
Xcamera_module_cache_reg_ram_104__7 dffr $PINS Q=camera_module_cache_ram_104__7
+ QB=#dummy[1957] D=nx20463 CLK=clk R=rst
Xix20464 mux21_ni $PINS Y=nx20463 A0=camera_module_cache_ram_104__7 A1=nx35634
+ S0=nx34552
Xix23965 nand04 $PINS Y=nx23964 A0=nx32873 A1=nx32881 A2=nx32889 A3=nx32897
Xix32874 aoi22 $PINS Y=nx32873 A0=camera_module_cache_ram_136__7 A1=nx36162
+ B0=camera_module_cache_ram_152__7 B1=nx36202
Xcamera_module_cache_reg_ram_136__7 dffr $PINS Q=camera_module_cache_ram_136__7
+ QB=#dummy[1958] D=nx20443 CLK=clk R=rst
Xix20444 mux21_ni $PINS Y=nx20443 A0=camera_module_cache_ram_136__7 A1=nx35634
+ S0=nx34544
Xcamera_module_cache_reg_ram_152__7 dffr $PINS Q=camera_module_cache_ram_152__7
+ QB=#dummy[1959] D=nx20433 CLK=clk R=rst
Xix20434 mux21_ni $PINS Y=nx20433 A0=camera_module_cache_ram_152__7 A1=nx35634
+ S0=nx34540
Xix32882 aoi22 $PINS Y=nx32881 A0=camera_module_cache_ram_184__7 A1=nx36242
+ B0=camera_module_cache_ram_168__7 B1=nx36282
Xcamera_module_cache_reg_ram_184__7 dffr $PINS Q=camera_module_cache_ram_184__7
+ QB=#dummy[1960] D=nx20413 CLK=clk R=rst
Xix20414 mux21_ni $PINS Y=nx20413 A0=camera_module_cache_ram_184__7 A1=nx35634
+ S0=nx34532
Xcamera_module_cache_reg_ram_168__7 dffr $PINS Q=camera_module_cache_ram_168__7
+ QB=#dummy[1961] D=nx20423 CLK=clk R=rst
Xix20424 mux21_ni $PINS Y=nx20423 A0=camera_module_cache_ram_168__7 A1=nx35634
+ S0=nx34536
Xix32890 aoi22 $PINS Y=nx32889 A0=camera_module_cache_ram_200__7 A1=nx36322
+ B0=camera_module_cache_ram_216__7 B1=nx36362
Xcamera_module_cache_reg_ram_200__7 dffr $PINS Q=camera_module_cache_ram_200__7
+ QB=#dummy[1962] D=nx20403 CLK=clk R=rst
Xix20404 mux21_ni $PINS Y=nx20403 A0=camera_module_cache_ram_200__7 A1=nx35636
+ S0=nx34528
Xcamera_module_cache_reg_ram_216__7 dffr $PINS Q=camera_module_cache_ram_216__7
+ QB=#dummy[1963] D=nx20393 CLK=clk R=rst
Xix20394 mux21_ni $PINS Y=nx20393 A0=camera_module_cache_ram_216__7 A1=nx35636
+ S0=nx34524
Xix32898 aoi22 $PINS Y=nx32897 A0=camera_module_cache_ram_232__7 A1=nx36402
+ B0=camera_module_cache_ram_248__7 B1=nx36442
Xcamera_module_cache_reg_ram_232__7 dffr $PINS Q=camera_module_cache_ram_232__7
+ QB=#dummy[1964] D=nx20383 CLK=clk R=rst
Xix20384 mux21_ni $PINS Y=nx20383 A0=camera_module_cache_ram_232__7 A1=nx35636
+ S0=nx34520
Xcamera_module_cache_reg_ram_248__7 dffr $PINS Q=camera_module_cache_ram_248__7
+ QB=#dummy[1965] D=nx20373 CLK=clk R=rst
Xix20374 mux21_ni $PINS Y=nx20373 A0=camera_module_cache_ram_248__7 A1=nx35636
+ S0=nx34516
Xix32906 oai21 $PINS Y=nx32905 A0=nx23880 A1=nx23802 B0=nx37268
Xix23881 nand04 $PINS Y=nx23880 A0=nx32908 A1=nx32916 A2=nx32924 A3=nx32932
Xix32909 aoi22 $PINS Y=nx32908 A0=camera_module_cache_ram_9__7 A1=nx35842
+ B0=camera_module_cache_ram_25__7 B1=nx35882
Xcamera_module_cache_reg_ram_9__7 dffr $PINS Q=camera_module_cache_ram_9__7
+ QB=#dummy[1966] D=nx20363 CLK=clk R=rst
Xix20364 mux21_ni $PINS Y=nx20363 A0=camera_module_cache_ram_9__7 A1=nx35636
+ S0=nx34506
Xcamera_module_cache_reg_ram_25__7 dffr $PINS Q=camera_module_cache_ram_25__7
+ QB=#dummy[1967] D=nx20353 CLK=clk R=rst
Xix20354 mux21_ni $PINS Y=nx20353 A0=camera_module_cache_ram_25__7 A1=nx35636
+ S0=nx34502
Xix32917 aoi22 $PINS Y=nx32916 A0=camera_module_cache_ram_41__7 A1=nx35922
+ B0=camera_module_cache_ram_57__7 B1=nx35962
Xcamera_module_cache_reg_ram_41__7 dffr $PINS Q=camera_module_cache_ram_41__7
+ QB=#dummy[1968] D=nx20343 CLK=clk R=rst
Xix20344 mux21_ni $PINS Y=nx20343 A0=camera_module_cache_ram_41__7 A1=nx35636
+ S0=nx34498
Xcamera_module_cache_reg_ram_57__7 dffr $PINS Q=camera_module_cache_ram_57__7
+ QB=#dummy[1969] D=nx20333 CLK=clk R=rst
Xix20334 mux21_ni $PINS Y=nx20333 A0=camera_module_cache_ram_57__7 A1=nx35638
+ S0=nx34494
Xix32925 aoi22 $PINS Y=nx32924 A0=camera_module_cache_ram_73__7 A1=nx36002
+ B0=camera_module_cache_ram_89__7 B1=nx36042
Xcamera_module_cache_reg_ram_73__7 dffr $PINS Q=camera_module_cache_ram_73__7
+ QB=#dummy[1970] D=nx20323 CLK=clk R=rst
Xix20324 mux21_ni $PINS Y=nx20323 A0=camera_module_cache_ram_73__7 A1=nx35638
+ S0=nx34490
Xcamera_module_cache_reg_ram_89__7 dffr $PINS Q=camera_module_cache_ram_89__7
+ QB=#dummy[1971] D=nx20313 CLK=clk R=rst
Xix20314 mux21_ni $PINS Y=nx20313 A0=camera_module_cache_ram_89__7 A1=nx35638
+ S0=nx34486
Xix32933 aoi22 $PINS Y=nx32932 A0=camera_module_cache_ram_121__7 A1=nx36082
+ B0=camera_module_cache_ram_105__7 B1=nx36122
Xcamera_module_cache_reg_ram_121__7 dffr $PINS Q=camera_module_cache_ram_121__7
+ QB=#dummy[1972] D=nx20293 CLK=clk R=rst
Xix20294 mux21_ni $PINS Y=nx20293 A0=camera_module_cache_ram_121__7 A1=nx35638
+ S0=nx34478
Xcamera_module_cache_reg_ram_105__7 dffr $PINS Q=camera_module_cache_ram_105__7
+ QB=#dummy[1973] D=nx20303 CLK=clk R=rst
Xix20304 mux21_ni $PINS Y=nx20303 A0=camera_module_cache_ram_105__7 A1=nx35638
+ S0=nx34482
Xix23803 nand04 $PINS Y=nx23802 A0=nx32941 A1=nx32949 A2=nx32957 A3=nx32965
Xix32942 aoi22 $PINS Y=nx32941 A0=camera_module_cache_ram_137__7 A1=nx36162
+ B0=camera_module_cache_ram_153__7 B1=nx36202
Xcamera_module_cache_reg_ram_137__7 dffr $PINS Q=camera_module_cache_ram_137__7
+ QB=#dummy[1974] D=nx20283 CLK=clk R=rst
Xix20284 mux21_ni $PINS Y=nx20283 A0=camera_module_cache_ram_137__7 A1=nx35638
+ S0=nx34474
Xcamera_module_cache_reg_ram_153__7 dffr $PINS Q=camera_module_cache_ram_153__7
+ QB=#dummy[1975] D=nx20273 CLK=clk R=rst
Xix20274 mux21_ni $PINS Y=nx20273 A0=camera_module_cache_ram_153__7 A1=nx35638
+ S0=nx34470
Xix32950 aoi22 $PINS Y=nx32949 A0=camera_module_cache_ram_185__7 A1=nx36242
+ B0=camera_module_cache_ram_169__7 B1=nx36282
Xcamera_module_cache_reg_ram_185__7 dffr $PINS Q=camera_module_cache_ram_185__7
+ QB=#dummy[1976] D=nx20253 CLK=clk R=rst
Xix20254 mux21_ni $PINS Y=nx20253 A0=camera_module_cache_ram_185__7 A1=nx35640
+ S0=nx34462
Xcamera_module_cache_reg_ram_169__7 dffr $PINS Q=camera_module_cache_ram_169__7
+ QB=#dummy[1977] D=nx20263 CLK=clk R=rst
Xix20264 mux21_ni $PINS Y=nx20263 A0=camera_module_cache_ram_169__7 A1=nx35640
+ S0=nx34466
Xix32958 aoi22 $PINS Y=nx32957 A0=camera_module_cache_ram_201__7 A1=nx36322
+ B0=camera_module_cache_ram_217__7 B1=nx36362
Xcamera_module_cache_reg_ram_201__7 dffr $PINS Q=camera_module_cache_ram_201__7
+ QB=#dummy[1978] D=nx20243 CLK=clk R=rst
Xix20244 mux21_ni $PINS Y=nx20243 A0=camera_module_cache_ram_201__7 A1=nx35640
+ S0=nx34458
Xcamera_module_cache_reg_ram_217__7 dffr $PINS Q=camera_module_cache_ram_217__7
+ QB=#dummy[1979] D=nx20233 CLK=clk R=rst
Xix20234 mux21_ni $PINS Y=nx20233 A0=camera_module_cache_ram_217__7 A1=nx35640
+ S0=nx34454
Xix32966 aoi22 $PINS Y=nx32965 A0=camera_module_cache_ram_233__7 A1=nx36402
+ B0=camera_module_cache_ram_249__7 B1=nx36442
Xcamera_module_cache_reg_ram_233__7 dffr $PINS Q=camera_module_cache_ram_233__7
+ QB=#dummy[1980] D=nx20223 CLK=clk R=rst
Xix20224 mux21_ni $PINS Y=nx20223 A0=camera_module_cache_ram_233__7 A1=nx35640
+ S0=nx34450
Xcamera_module_cache_reg_ram_249__7 dffr $PINS Q=camera_module_cache_ram_249__7
+ QB=#dummy[1981] D=nx20213 CLK=clk R=rst
Xix20214 mux21_ni $PINS Y=nx20213 A0=camera_module_cache_ram_249__7 A1=nx35640
+ S0=nx34446
Xix32974 oai21 $PINS Y=nx32973 A0=nx23716 A1=nx23638 B0=nx37272
Xix23717 nand04 $PINS Y=nx23716 A0=nx32976 A1=nx32984 A2=nx32992 A3=nx33000
Xix32977 aoi22 $PINS Y=nx32976 A0=camera_module_cache_ram_10__7 A1=nx37200
+ B0=camera_module_cache_ram_26__7 B1=nx37202
Xcamera_module_cache_reg_ram_10__7 dffr $PINS Q=camera_module_cache_ram_10__7
+ QB=#dummy[1982] D=nx20203 CLK=clk R=rst
Xix20204 mux21_ni $PINS Y=nx20203 A0=camera_module_cache_ram_10__7 A1=nx35640
+ S0=nx34436
Xcamera_module_cache_reg_ram_26__7 dffr $PINS Q=camera_module_cache_ram_26__7
+ QB=#dummy[1983] D=nx20193 CLK=clk R=rst
Xix20194 mux21_ni $PINS Y=nx20193 A0=camera_module_cache_ram_26__7 A1=nx35642
+ S0=nx34432
Xix32985 aoi22 $PINS Y=nx32984 A0=camera_module_cache_ram_42__7 A1=nx37204
+ B0=camera_module_cache_ram_58__7 B1=nx37206
Xcamera_module_cache_reg_ram_42__7 dffr $PINS Q=camera_module_cache_ram_42__7
+ QB=#dummy[1984] D=nx20183 CLK=clk R=rst
Xix20184 mux21_ni $PINS Y=nx20183 A0=camera_module_cache_ram_42__7 A1=nx35642
+ S0=nx34428
Xcamera_module_cache_reg_ram_58__7 dffr $PINS Q=camera_module_cache_ram_58__7
+ QB=#dummy[1985] D=nx20173 CLK=clk R=rst
Xix20174 mux21_ni $PINS Y=nx20173 A0=camera_module_cache_ram_58__7 A1=nx35642
+ S0=nx34424
Xix32993 aoi22 $PINS Y=nx32992 A0=camera_module_cache_ram_74__7 A1=nx37208
+ B0=camera_module_cache_ram_90__7 B1=nx37210
Xcamera_module_cache_reg_ram_74__7 dffr $PINS Q=camera_module_cache_ram_74__7
+ QB=#dummy[1986] D=nx20163 CLK=clk R=rst
Xix20164 mux21_ni $PINS Y=nx20163 A0=camera_module_cache_ram_74__7 A1=nx35642
+ S0=nx34420
Xcamera_module_cache_reg_ram_90__7 dffr $PINS Q=camera_module_cache_ram_90__7
+ QB=#dummy[1987] D=nx20153 CLK=clk R=rst
Xix20154 mux21_ni $PINS Y=nx20153 A0=camera_module_cache_ram_90__7 A1=nx35642
+ S0=nx34416
Xix33001 aoi22 $PINS Y=nx33000 A0=camera_module_cache_ram_122__7 A1=nx37212
+ B0=camera_module_cache_ram_106__7 B1=nx37214
Xcamera_module_cache_reg_ram_122__7 dffr $PINS Q=camera_module_cache_ram_122__7
+ QB=#dummy[1988] D=nx20133 CLK=clk R=rst
Xix20134 mux21_ni $PINS Y=nx20133 A0=camera_module_cache_ram_122__7 A1=nx35642
+ S0=nx34408
Xcamera_module_cache_reg_ram_106__7 dffr $PINS Q=camera_module_cache_ram_106__7
+ QB=#dummy[1989] D=nx20143 CLK=clk R=rst
Xix20144 mux21_ni $PINS Y=nx20143 A0=camera_module_cache_ram_106__7 A1=nx35642
+ S0=nx34412
Xix23639 nand04 $PINS Y=nx23638 A0=nx33009 A1=nx33017 A2=nx33025 A3=nx33033
Xix33010 aoi22 $PINS Y=nx33009 A0=camera_module_cache_ram_138__7 A1=nx37216
+ B0=camera_module_cache_ram_154__7 B1=nx37218
Xcamera_module_cache_reg_ram_138__7 dffr $PINS Q=camera_module_cache_ram_138__7
+ QB=#dummy[1990] D=nx20123 CLK=clk R=rst
Xix20124 mux21_ni $PINS Y=nx20123 A0=camera_module_cache_ram_138__7 A1=nx35644
+ S0=nx34404
Xcamera_module_cache_reg_ram_154__7 dffr $PINS Q=camera_module_cache_ram_154__7
+ QB=#dummy[1991] D=nx20113 CLK=clk R=rst
Xix20114 mux21_ni $PINS Y=nx20113 A0=camera_module_cache_ram_154__7 A1=nx35644
+ S0=nx34400
Xix33018 aoi22 $PINS Y=nx33017 A0=camera_module_cache_ram_186__7 A1=nx37220
+ B0=camera_module_cache_ram_170__7 B1=nx37222
Xcamera_module_cache_reg_ram_186__7 dffr $PINS Q=camera_module_cache_ram_186__7
+ QB=#dummy[1992] D=nx20093 CLK=clk R=rst
Xix20094 mux21_ni $PINS Y=nx20093 A0=camera_module_cache_ram_186__7 A1=nx35644
+ S0=nx34392
Xcamera_module_cache_reg_ram_170__7 dffr $PINS Q=camera_module_cache_ram_170__7
+ QB=#dummy[1993] D=nx20103 CLK=clk R=rst
Xix20104 mux21_ni $PINS Y=nx20103 A0=camera_module_cache_ram_170__7 A1=nx35644
+ S0=nx34396
Xix33026 aoi22 $PINS Y=nx33025 A0=camera_module_cache_ram_202__7 A1=nx37224
+ B0=camera_module_cache_ram_218__7 B1=nx37226
Xcamera_module_cache_reg_ram_202__7 dffr $PINS Q=camera_module_cache_ram_202__7
+ QB=#dummy[1994] D=nx20083 CLK=clk R=rst
Xix20084 mux21_ni $PINS Y=nx20083 A0=camera_module_cache_ram_202__7 A1=nx35644
+ S0=nx34388
Xcamera_module_cache_reg_ram_218__7 dffr $PINS Q=camera_module_cache_ram_218__7
+ QB=#dummy[1995] D=nx20073 CLK=clk R=rst
Xix20074 mux21_ni $PINS Y=nx20073 A0=camera_module_cache_ram_218__7 A1=nx35644
+ S0=nx34384
Xix33034 aoi22 $PINS Y=nx33033 A0=camera_module_cache_ram_234__7 A1=nx37228
+ B0=camera_module_cache_ram_250__7 B1=nx37230
Xcamera_module_cache_reg_ram_234__7 dffr $PINS Q=camera_module_cache_ram_234__7
+ QB=#dummy[1996] D=nx20063 CLK=clk R=rst
Xix20064 mux21_ni $PINS Y=nx20063 A0=camera_module_cache_ram_234__7 A1=nx35644
+ S0=nx34380
Xcamera_module_cache_reg_ram_250__7 dffr $PINS Q=camera_module_cache_ram_250__7
+ QB=#dummy[1997] D=nx20053 CLK=clk R=rst
Xix20054 mux21_ni $PINS Y=nx20053 A0=camera_module_cache_ram_250__7 A1=nx35646
+ S0=nx34376
Xix33042 oai21 $PINS Y=nx33041 A0=nx23554 A1=nx23476 B0=nx37276
Xix23555 nand04 $PINS Y=nx23554 A0=nx33044 A1=nx33052 A2=nx33060 A3=nx33068
Xix33045 aoi22 $PINS Y=nx33044 A0=camera_module_cache_ram_11__7 A1=nx37200
+ B0=camera_module_cache_ram_27__7 B1=nx37202
Xcamera_module_cache_reg_ram_11__7 dffr $PINS Q=camera_module_cache_ram_11__7
+ QB=#dummy[1998] D=nx20043 CLK=clk R=rst
Xix20044 mux21_ni $PINS Y=nx20043 A0=camera_module_cache_ram_11__7 A1=nx35646
+ S0=nx34366
Xcamera_module_cache_reg_ram_27__7 dffr $PINS Q=camera_module_cache_ram_27__7
+ QB=#dummy[1999] D=nx20033 CLK=clk R=rst
Xix20034 mux21_ni $PINS Y=nx20033 A0=camera_module_cache_ram_27__7 A1=nx35646
+ S0=nx34362
Xix33053 aoi22 $PINS Y=nx33052 A0=camera_module_cache_ram_43__7 A1=nx37204
+ B0=camera_module_cache_ram_59__7 B1=nx37206
Xcamera_module_cache_reg_ram_43__7 dffr $PINS Q=camera_module_cache_ram_43__7
+ QB=#dummy[2000] D=nx20023 CLK=clk R=rst
Xix20024 mux21_ni $PINS Y=nx20023 A0=camera_module_cache_ram_43__7 A1=nx35646
+ S0=nx34358
Xcamera_module_cache_reg_ram_59__7 dffr $PINS Q=camera_module_cache_ram_59__7
+ QB=#dummy[2001] D=nx20013 CLK=clk R=rst
Xix20014 mux21_ni $PINS Y=nx20013 A0=camera_module_cache_ram_59__7 A1=nx35646
+ S0=nx34354
Xix33061 aoi22 $PINS Y=nx33060 A0=camera_module_cache_ram_75__7 A1=nx37208
+ B0=camera_module_cache_ram_91__7 B1=nx37210
Xcamera_module_cache_reg_ram_75__7 dffr $PINS Q=camera_module_cache_ram_75__7
+ QB=#dummy[2002] D=nx20003 CLK=clk R=rst
Xix20004 mux21_ni $PINS Y=nx20003 A0=camera_module_cache_ram_75__7 A1=nx35646
+ S0=nx34350
Xcamera_module_cache_reg_ram_91__7 dffr $PINS Q=camera_module_cache_ram_91__7
+ QB=#dummy[2003] D=nx19993 CLK=clk R=rst
Xix19994 mux21_ni $PINS Y=nx19993 A0=camera_module_cache_ram_91__7 A1=nx35646
+ S0=nx34346
Xix33069 aoi22 $PINS Y=nx33068 A0=camera_module_cache_ram_123__7 A1=nx37212
+ B0=camera_module_cache_ram_107__7 B1=nx37214
Xcamera_module_cache_reg_ram_123__7 dffr $PINS Q=camera_module_cache_ram_123__7
+ QB=#dummy[2004] D=nx19973 CLK=clk R=rst
Xix19974 mux21_ni $PINS Y=nx19973 A0=camera_module_cache_ram_123__7 A1=nx35648
+ S0=nx34338
Xcamera_module_cache_reg_ram_107__7 dffr $PINS Q=camera_module_cache_ram_107__7
+ QB=#dummy[2005] D=nx19983 CLK=clk R=rst
Xix19984 mux21_ni $PINS Y=nx19983 A0=camera_module_cache_ram_107__7 A1=nx35648
+ S0=nx34342
Xix23477 nand04 $PINS Y=nx23476 A0=nx33077 A1=nx33085 A2=nx33093 A3=nx33101
Xix33078 aoi22 $PINS Y=nx33077 A0=camera_module_cache_ram_139__7 A1=nx37216
+ B0=camera_module_cache_ram_155__7 B1=nx37218
Xcamera_module_cache_reg_ram_139__7 dffr $PINS Q=camera_module_cache_ram_139__7
+ QB=#dummy[2006] D=nx19963 CLK=clk R=rst
Xix19964 mux21_ni $PINS Y=nx19963 A0=camera_module_cache_ram_139__7 A1=nx35648
+ S0=nx34334
Xcamera_module_cache_reg_ram_155__7 dffr $PINS Q=camera_module_cache_ram_155__7
+ QB=#dummy[2007] D=nx19953 CLK=clk R=rst
Xix19954 mux21_ni $PINS Y=nx19953 A0=camera_module_cache_ram_155__7 A1=nx35648
+ S0=nx34330
Xix33086 aoi22 $PINS Y=nx33085 A0=camera_module_cache_ram_187__7 A1=nx37220
+ B0=camera_module_cache_ram_171__7 B1=nx37222
Xcamera_module_cache_reg_ram_187__7 dffr $PINS Q=camera_module_cache_ram_187__7
+ QB=#dummy[2008] D=nx19933 CLK=clk R=rst
Xix19934 mux21_ni $PINS Y=nx19933 A0=camera_module_cache_ram_187__7 A1=nx35648
+ S0=nx34322
Xcamera_module_cache_reg_ram_171__7 dffr $PINS Q=camera_module_cache_ram_171__7
+ QB=#dummy[2009] D=nx19943 CLK=clk R=rst
Xix19944 mux21_ni $PINS Y=nx19943 A0=camera_module_cache_ram_171__7 A1=nx35648
+ S0=nx34326
Xix33094 aoi22 $PINS Y=nx33093 A0=camera_module_cache_ram_203__7 A1=nx37224
+ B0=camera_module_cache_ram_219__7 B1=nx37226
Xcamera_module_cache_reg_ram_203__7 dffr $PINS Q=camera_module_cache_ram_203__7
+ QB=#dummy[2010] D=nx19923 CLK=clk R=rst
Xix19924 mux21_ni $PINS Y=nx19923 A0=camera_module_cache_ram_203__7 A1=nx35648
+ S0=nx34318
Xcamera_module_cache_reg_ram_219__7 dffr $PINS Q=camera_module_cache_ram_219__7
+ QB=#dummy[2011] D=nx19913 CLK=clk R=rst
Xix19914 mux21_ni $PINS Y=nx19913 A0=camera_module_cache_ram_219__7 A1=nx35650
+ S0=nx34314
Xix33102 aoi22 $PINS Y=nx33101 A0=camera_module_cache_ram_235__7 A1=nx37228
+ B0=camera_module_cache_ram_251__7 B1=nx37230
Xcamera_module_cache_reg_ram_235__7 dffr $PINS Q=camera_module_cache_ram_235__7
+ QB=#dummy[2012] D=nx19903 CLK=clk R=rst
Xix19904 mux21_ni $PINS Y=nx19903 A0=camera_module_cache_ram_235__7 A1=nx35650
+ S0=nx34310
Xcamera_module_cache_reg_ram_251__7 dffr $PINS Q=camera_module_cache_ram_251__7
+ QB=#dummy[2013] D=nx19893 CLK=clk R=rst
Xix19894 mux21_ni $PINS Y=nx19893 A0=camera_module_cache_ram_251__7 A1=nx35650
+ S0=nx34306
Xix23399 nand04 $PINS Y=nx23398 A0=nx33110 A1=nx33178 A2=nx33246 A3=nx33314
Xix33111 oai21 $PINS Y=nx33110 A0=nx23388 A1=nx23310 B0=nx36508
Xix23389 nand04 $PINS Y=nx23388 A0=nx33113 A1=nx33121 A2=nx33129 A3=nx33137
Xix33114 aoi22 $PINS Y=nx33113 A0=camera_module_cache_ram_12__7 A1=nx37200
+ B0=camera_module_cache_ram_28__7 B1=nx37202
Xcamera_module_cache_reg_ram_12__7 dffr $PINS Q=camera_module_cache_ram_12__7
+ QB=#dummy[2014] D=nx19883 CLK=clk R=rst
Xix19884 mux21_ni $PINS Y=nx19883 A0=nx35650 A1=camera_module_cache_ram_12__7
+ S0=nx36498
Xcamera_module_cache_reg_ram_28__7 dffr $PINS Q=camera_module_cache_ram_28__7
+ QB=#dummy[2015] D=nx19873 CLK=clk R=rst
Xix19874 mux21_ni $PINS Y=nx19873 A0=nx35650 A1=camera_module_cache_ram_28__7
+ S0=nx36512
Xix33122 aoi22 $PINS Y=nx33121 A0=camera_module_cache_ram_44__7 A1=nx37204
+ B0=camera_module_cache_ram_60__7 B1=nx37206
Xcamera_module_cache_reg_ram_44__7 dffr $PINS Q=camera_module_cache_ram_44__7
+ QB=#dummy[2016] D=nx19863 CLK=clk R=rst
Xix19864 mux21_ni $PINS Y=nx19863 A0=nx35650 A1=camera_module_cache_ram_44__7
+ S0=nx36516
Xcamera_module_cache_reg_ram_60__7 dffr $PINS Q=camera_module_cache_ram_60__7
+ QB=#dummy[2017] D=nx19853 CLK=clk R=rst
Xix19854 mux21_ni $PINS Y=nx19853 A0=nx35650 A1=camera_module_cache_ram_60__7
+ S0=nx36520
Xix33130 aoi22 $PINS Y=nx33129 A0=camera_module_cache_ram_76__7 A1=nx37208
+ B0=camera_module_cache_ram_92__7 B1=nx37210
Xcamera_module_cache_reg_ram_76__7 dffr $PINS Q=camera_module_cache_ram_76__7
+ QB=#dummy[2018] D=nx19843 CLK=clk R=rst
Xix19844 mux21_ni $PINS Y=nx19843 A0=nx35652 A1=camera_module_cache_ram_76__7
+ S0=nx36524
Xcamera_module_cache_reg_ram_92__7 dffr $PINS Q=camera_module_cache_ram_92__7
+ QB=#dummy[2019] D=nx19833 CLK=clk R=rst
Xix19834 mux21_ni $PINS Y=nx19833 A0=nx35652 A1=camera_module_cache_ram_92__7
+ S0=nx36528
Xix33138 aoi22 $PINS Y=nx33137 A0=camera_module_cache_ram_124__7 A1=nx37212
+ B0=camera_module_cache_ram_108__7 B1=nx37214
Xcamera_module_cache_reg_ram_124__7 dffr $PINS Q=camera_module_cache_ram_124__7
+ QB=#dummy[2020] D=nx19813 CLK=clk R=rst
Xix19814 mux21_ni $PINS Y=nx19813 A0=nx35652 A1=camera_module_cache_ram_124__7
+ S0=nx36532
Xcamera_module_cache_reg_ram_108__7 dffr $PINS Q=camera_module_cache_ram_108__7
+ QB=#dummy[2021] D=nx19823 CLK=clk R=rst
Xix19824 mux21_ni $PINS Y=nx19823 A0=nx35652 A1=camera_module_cache_ram_108__7
+ S0=nx36536
Xix23311 nand04 $PINS Y=nx23310 A0=nx33146 A1=nx33154 A2=nx33162 A3=nx33170
Xix33147 aoi22 $PINS Y=nx33146 A0=camera_module_cache_ram_140__7 A1=nx37216
+ B0=camera_module_cache_ram_156__7 B1=nx37218
Xcamera_module_cache_reg_ram_140__7 dffr $PINS Q=camera_module_cache_ram_140__7
+ QB=#dummy[2022] D=nx19803 CLK=clk R=rst
Xix19804 mux21_ni $PINS Y=nx19803 A0=nx35652 A1=camera_module_cache_ram_140__7
+ S0=nx36540
Xcamera_module_cache_reg_ram_156__7 dffr $PINS Q=camera_module_cache_ram_156__7
+ QB=#dummy[2023] D=nx19793 CLK=clk R=rst
Xix19794 mux21_ni $PINS Y=nx19793 A0=nx35652 A1=camera_module_cache_ram_156__7
+ S0=nx36544
Xix33155 aoi22 $PINS Y=nx33154 A0=camera_module_cache_ram_188__7 A1=nx37220
+ B0=camera_module_cache_ram_172__7 B1=nx37222
Xcamera_module_cache_reg_ram_188__7 dffr $PINS Q=camera_module_cache_ram_188__7
+ QB=#dummy[2024] D=nx19773 CLK=clk R=rst
Xix19774 mux21_ni $PINS Y=nx19773 A0=nx35652 A1=camera_module_cache_ram_188__7
+ S0=nx36548
Xcamera_module_cache_reg_ram_172__7 dffr $PINS Q=camera_module_cache_ram_172__7
+ QB=#dummy[2025] D=nx19783 CLK=clk R=rst
Xix19784 mux21_ni $PINS Y=nx19783 A0=nx35654 A1=camera_module_cache_ram_172__7
+ S0=nx36552
Xix33163 aoi22 $PINS Y=nx33162 A0=camera_module_cache_ram_204__7 A1=nx37224
+ B0=camera_module_cache_ram_220__7 B1=nx37226
Xcamera_module_cache_reg_ram_204__7 dffr $PINS Q=camera_module_cache_ram_204__7
+ QB=#dummy[2026] D=nx19763 CLK=clk R=rst
Xix19764 mux21_ni $PINS Y=nx19763 A0=nx35654 A1=camera_module_cache_ram_204__7
+ S0=nx36556
Xcamera_module_cache_reg_ram_220__7 dffr $PINS Q=camera_module_cache_ram_220__7
+ QB=#dummy[2027] D=nx19753 CLK=clk R=rst
Xix19754 mux21_ni $PINS Y=nx19753 A0=nx35654 A1=camera_module_cache_ram_220__7
+ S0=nx36560
Xix33171 aoi22 $PINS Y=nx33170 A0=camera_module_cache_ram_236__7 A1=nx37228
+ B0=camera_module_cache_ram_252__7 B1=nx37230
Xcamera_module_cache_reg_ram_236__7 dffr $PINS Q=camera_module_cache_ram_236__7
+ QB=#dummy[2028] D=nx19743 CLK=clk R=rst
Xix19744 mux21_ni $PINS Y=nx19743 A0=nx35654 A1=camera_module_cache_ram_236__7
+ S0=nx36564
Xcamera_module_cache_reg_ram_252__7 dffr $PINS Q=camera_module_cache_ram_252__7
+ QB=#dummy[2029] D=nx19733 CLK=clk R=rst
Xix19734 mux21_ni $PINS Y=nx19733 A0=nx35654 A1=camera_module_cache_ram_252__7
+ S0=nx36568
Xix33179 oai21 $PINS Y=nx33178 A0=nx23226 A1=nx23148 B0=nx36582
Xix23227 nand04 $PINS Y=nx23226 A0=nx33181 A1=nx33189 A2=nx33197 A3=nx33205
Xix33182 aoi22 $PINS Y=nx33181 A0=camera_module_cache_ram_13__7 A1=nx37200
+ B0=camera_module_cache_ram_29__7 B1=nx37202
Xcamera_module_cache_reg_ram_13__7 dffr $PINS Q=camera_module_cache_ram_13__7
+ QB=#dummy[2030] D=nx19723 CLK=clk R=rst
Xix19724 mux21_ni $PINS Y=nx19723 A0=nx35654 A1=camera_module_cache_ram_13__7
+ S0=nx36572
Xcamera_module_cache_reg_ram_29__7 dffr $PINS Q=camera_module_cache_ram_29__7
+ QB=#dummy[2031] D=nx19713 CLK=clk R=rst
Xix19714 mux21_ni $PINS Y=nx19713 A0=nx35654 A1=camera_module_cache_ram_29__7
+ S0=nx36586
Xix33190 aoi22 $PINS Y=nx33189 A0=camera_module_cache_ram_45__7 A1=nx37204
+ B0=camera_module_cache_ram_61__7 B1=nx37206
Xcamera_module_cache_reg_ram_45__7 dffr $PINS Q=camera_module_cache_ram_45__7
+ QB=#dummy[2032] D=nx19703 CLK=clk R=rst
Xix19704 mux21_ni $PINS Y=nx19703 A0=nx35656 A1=camera_module_cache_ram_45__7
+ S0=nx36590
Xcamera_module_cache_reg_ram_61__7 dffr $PINS Q=camera_module_cache_ram_61__7
+ QB=#dummy[2033] D=nx19693 CLK=clk R=rst
Xix19694 mux21_ni $PINS Y=nx19693 A0=nx35656 A1=camera_module_cache_ram_61__7
+ S0=nx36594
Xix33198 aoi22 $PINS Y=nx33197 A0=camera_module_cache_ram_77__7 A1=nx37208
+ B0=camera_module_cache_ram_93__7 B1=nx37210
Xcamera_module_cache_reg_ram_77__7 dffr $PINS Q=camera_module_cache_ram_77__7
+ QB=#dummy[2034] D=nx19683 CLK=clk R=rst
Xix19684 mux21_ni $PINS Y=nx19683 A0=nx35656 A1=camera_module_cache_ram_77__7
+ S0=nx36598
Xcamera_module_cache_reg_ram_93__7 dffr $PINS Q=camera_module_cache_ram_93__7
+ QB=#dummy[2035] D=nx19673 CLK=clk R=rst
Xix19674 mux21_ni $PINS Y=nx19673 A0=nx35656 A1=camera_module_cache_ram_93__7
+ S0=nx36602
Xix33206 aoi22 $PINS Y=nx33205 A0=camera_module_cache_ram_125__7 A1=nx37212
+ B0=camera_module_cache_ram_109__7 B1=nx37214
Xcamera_module_cache_reg_ram_125__7 dffr $PINS Q=camera_module_cache_ram_125__7
+ QB=#dummy[2036] D=nx19653 CLK=clk R=rst
Xix19654 mux21_ni $PINS Y=nx19653 A0=nx35656 A1=camera_module_cache_ram_125__7
+ S0=nx36606
Xcamera_module_cache_reg_ram_109__7 dffr $PINS Q=camera_module_cache_ram_109__7
+ QB=#dummy[2037] D=nx19663 CLK=clk R=rst
Xix19664 mux21_ni $PINS Y=nx19663 A0=nx35656 A1=camera_module_cache_ram_109__7
+ S0=nx36610
Xix23149 nand04 $PINS Y=nx23148 A0=nx33214 A1=nx33222 A2=nx33230 A3=nx33238
Xix33215 aoi22 $PINS Y=nx33214 A0=camera_module_cache_ram_141__7 A1=nx37216
+ B0=camera_module_cache_ram_157__7 B1=nx37218
Xcamera_module_cache_reg_ram_141__7 dffr $PINS Q=camera_module_cache_ram_141__7
+ QB=#dummy[2038] D=nx19643 CLK=clk R=rst
Xix19644 mux21_ni $PINS Y=nx19643 A0=nx35656 A1=camera_module_cache_ram_141__7
+ S0=nx36614
Xcamera_module_cache_reg_ram_157__7 dffr $PINS Q=camera_module_cache_ram_157__7
+ QB=#dummy[2039] D=nx19633 CLK=clk R=rst
Xix19634 mux21_ni $PINS Y=nx19633 A0=nx35658 A1=camera_module_cache_ram_157__7
+ S0=nx36618
Xix33223 aoi22 $PINS Y=nx33222 A0=camera_module_cache_ram_189__7 A1=nx37220
+ B0=camera_module_cache_ram_173__7 B1=nx37222
Xcamera_module_cache_reg_ram_189__7 dffr $PINS Q=camera_module_cache_ram_189__7
+ QB=#dummy[2040] D=nx19613 CLK=clk R=rst
Xix19614 mux21_ni $PINS Y=nx19613 A0=nx35658 A1=camera_module_cache_ram_189__7
+ S0=nx36622
Xcamera_module_cache_reg_ram_173__7 dffr $PINS Q=camera_module_cache_ram_173__7
+ QB=#dummy[2041] D=nx19623 CLK=clk R=rst
Xix19624 mux21_ni $PINS Y=nx19623 A0=nx35658 A1=camera_module_cache_ram_173__7
+ S0=nx36626
Xix33231 aoi22 $PINS Y=nx33230 A0=camera_module_cache_ram_205__7 A1=nx37224
+ B0=camera_module_cache_ram_221__7 B1=nx37226
Xcamera_module_cache_reg_ram_205__7 dffr $PINS Q=camera_module_cache_ram_205__7
+ QB=#dummy[2042] D=nx19603 CLK=clk R=rst
Xix19604 mux21_ni $PINS Y=nx19603 A0=nx35658 A1=camera_module_cache_ram_205__7
+ S0=nx36630
Xcamera_module_cache_reg_ram_221__7 dffr $PINS Q=camera_module_cache_ram_221__7
+ QB=#dummy[2043] D=nx19593 CLK=clk R=rst
Xix19594 mux21_ni $PINS Y=nx19593 A0=nx35658 A1=camera_module_cache_ram_221__7
+ S0=nx36634
Xix33239 aoi22 $PINS Y=nx33238 A0=camera_module_cache_ram_237__7 A1=nx37228
+ B0=camera_module_cache_ram_253__7 B1=nx37230
Xcamera_module_cache_reg_ram_237__7 dffr $PINS Q=camera_module_cache_ram_237__7
+ QB=#dummy[2044] D=nx19583 CLK=clk R=rst
Xix19584 mux21_ni $PINS Y=nx19583 A0=nx35658 A1=camera_module_cache_ram_237__7
+ S0=nx36638
Xcamera_module_cache_reg_ram_253__7 dffr $PINS Q=camera_module_cache_ram_253__7
+ QB=#dummy[2045] D=nx19573 CLK=clk R=rst
Xix19574 mux21_ni $PINS Y=nx19573 A0=nx35658 A1=camera_module_cache_ram_253__7
+ S0=nx36642
Xix33247 oai21 $PINS Y=nx33246 A0=nx23062 A1=nx22984 B0=nx36656
Xix23063 nand04 $PINS Y=nx23062 A0=nx33249 A1=nx33257 A2=nx33265 A3=nx33273
Xix33250 aoi22 $PINS Y=nx33249 A0=camera_module_cache_ram_14__7 A1=nx37200
+ B0=camera_module_cache_ram_30__7 B1=nx37202
Xcamera_module_cache_reg_ram_14__7 dffr $PINS Q=camera_module_cache_ram_14__7
+ QB=#dummy[2046] D=nx19563 CLK=clk R=rst
Xix19564 mux21_ni $PINS Y=nx19563 A0=nx35660 A1=camera_module_cache_ram_14__7
+ S0=nx36646
Xcamera_module_cache_reg_ram_30__7 dffr $PINS Q=camera_module_cache_ram_30__7
+ QB=#dummy[2047] D=nx19553 CLK=clk R=rst
Xix19554 mux21_ni $PINS Y=nx19553 A0=nx35660 A1=camera_module_cache_ram_30__7
+ S0=nx36660
Xix33258 aoi22 $PINS Y=nx33257 A0=camera_module_cache_ram_46__7 A1=nx37204
+ B0=camera_module_cache_ram_62__7 B1=nx37206
Xcamera_module_cache_reg_ram_46__7 dffr $PINS Q=camera_module_cache_ram_46__7
+ QB=#dummy[2048] D=nx19543 CLK=clk R=rst
Xix19544 mux21_ni $PINS Y=nx19543 A0=nx35660 A1=camera_module_cache_ram_46__7
+ S0=nx36664
Xcamera_module_cache_reg_ram_62__7 dffr $PINS Q=camera_module_cache_ram_62__7
+ QB=#dummy[2049] D=nx19533 CLK=clk R=rst
Xix19534 mux21_ni $PINS Y=nx19533 A0=nx35660 A1=camera_module_cache_ram_62__7
+ S0=nx36668
Xix33266 aoi22 $PINS Y=nx33265 A0=camera_module_cache_ram_78__7 A1=nx37208
+ B0=camera_module_cache_ram_94__7 B1=nx37210
Xcamera_module_cache_reg_ram_78__7 dffr $PINS Q=camera_module_cache_ram_78__7
+ QB=#dummy[2050] D=nx19523 CLK=clk R=rst
Xix19524 mux21_ni $PINS Y=nx19523 A0=nx35660 A1=camera_module_cache_ram_78__7
+ S0=nx36672
Xcamera_module_cache_reg_ram_94__7 dffr $PINS Q=camera_module_cache_ram_94__7
+ QB=#dummy[2051] D=nx19513 CLK=clk R=rst
Xix19514 mux21_ni $PINS Y=nx19513 A0=nx35660 A1=camera_module_cache_ram_94__7
+ S0=nx36676
Xix33274 aoi22 $PINS Y=nx33273 A0=camera_module_cache_ram_126__7 A1=nx37212
+ B0=camera_module_cache_ram_110__7 B1=nx37214
Xcamera_module_cache_reg_ram_126__7 dffr $PINS Q=camera_module_cache_ram_126__7
+ QB=#dummy[2052] D=nx19493 CLK=clk R=rst
Xix19494 mux21_ni $PINS Y=nx19493 A0=nx35660 A1=camera_module_cache_ram_126__7
+ S0=nx36680
Xcamera_module_cache_reg_ram_110__7 dffr $PINS Q=camera_module_cache_ram_110__7
+ QB=#dummy[2053] D=nx19503 CLK=clk R=rst
Xix19504 mux21_ni $PINS Y=nx19503 A0=nx35662 A1=camera_module_cache_ram_110__7
+ S0=nx36684
Xix22985 nand04 $PINS Y=nx22984 A0=nx33282 A1=nx33290 A2=nx33298 A3=nx33306
Xix33283 aoi22 $PINS Y=nx33282 A0=camera_module_cache_ram_142__7 A1=nx37216
+ B0=camera_module_cache_ram_158__7 B1=nx37218
Xcamera_module_cache_reg_ram_142__7 dffr $PINS Q=camera_module_cache_ram_142__7
+ QB=#dummy[2054] D=nx19483 CLK=clk R=rst
Xix19484 mux21_ni $PINS Y=nx19483 A0=nx35662 A1=camera_module_cache_ram_142__7
+ S0=nx36688
Xcamera_module_cache_reg_ram_158__7 dffr $PINS Q=camera_module_cache_ram_158__7
+ QB=#dummy[2055] D=nx19473 CLK=clk R=rst
Xix19474 mux21_ni $PINS Y=nx19473 A0=nx35662 A1=camera_module_cache_ram_158__7
+ S0=nx36692
Xix33291 aoi22 $PINS Y=nx33290 A0=camera_module_cache_ram_190__7 A1=nx37220
+ B0=camera_module_cache_ram_174__7 B1=nx37222
Xcamera_module_cache_reg_ram_190__7 dffr $PINS Q=camera_module_cache_ram_190__7
+ QB=#dummy[2056] D=nx19453 CLK=clk R=rst
Xix19454 mux21_ni $PINS Y=nx19453 A0=nx35662 A1=camera_module_cache_ram_190__7
+ S0=nx36696
Xcamera_module_cache_reg_ram_174__7 dffr $PINS Q=camera_module_cache_ram_174__7
+ QB=#dummy[2057] D=nx19463 CLK=clk R=rst
Xix19464 mux21_ni $PINS Y=nx19463 A0=nx35662 A1=camera_module_cache_ram_174__7
+ S0=nx36700
Xix33299 aoi22 $PINS Y=nx33298 A0=camera_module_cache_ram_206__7 A1=nx37224
+ B0=camera_module_cache_ram_222__7 B1=nx37226
Xcamera_module_cache_reg_ram_206__7 dffr $PINS Q=camera_module_cache_ram_206__7
+ QB=#dummy[2058] D=nx19443 CLK=clk R=rst
Xix19444 mux21_ni $PINS Y=nx19443 A0=nx35662 A1=camera_module_cache_ram_206__7
+ S0=nx36704
Xcamera_module_cache_reg_ram_222__7 dffr $PINS Q=camera_module_cache_ram_222__7
+ QB=#dummy[2059] D=nx19433 CLK=clk R=rst
Xix19434 mux21_ni $PINS Y=nx19433 A0=nx35662 A1=camera_module_cache_ram_222__7
+ S0=nx36708
Xix33307 aoi22 $PINS Y=nx33306 A0=camera_module_cache_ram_238__7 A1=nx37228
+ B0=camera_module_cache_ram_254__7 B1=nx37230
Xcamera_module_cache_reg_ram_238__7 dffr $PINS Q=camera_module_cache_ram_238__7
+ QB=#dummy[2060] D=nx19423 CLK=clk R=rst
Xix19424 mux21_ni $PINS Y=nx19423 A0=nx35664 A1=camera_module_cache_ram_238__7
+ S0=nx36712
Xcamera_module_cache_reg_ram_254__7 dffr $PINS Q=camera_module_cache_ram_254__7
+ QB=#dummy[2061] D=nx19413 CLK=clk R=rst
Xix19414 mux21_ni $PINS Y=nx19413 A0=nx35664 A1=camera_module_cache_ram_254__7
+ S0=nx36716
Xix33315 oai21 $PINS Y=nx33314 A0=nx22900 A1=nx22822 B0=nx36730
Xix22901 nand04 $PINS Y=nx22900 A0=nx33317 A1=nx33325 A2=nx33333 A3=nx33341
Xix33318 aoi22 $PINS Y=nx33317 A0=camera_module_cache_ram_15__7 A1=nx37200
+ B0=camera_module_cache_ram_31__7 B1=nx37202
Xcamera_module_cache_reg_ram_15__7 dffr $PINS Q=camera_module_cache_ram_15__7
+ QB=#dummy[2062] D=nx19403 CLK=clk R=rst
Xix19404 mux21_ni $PINS Y=nx19403 A0=nx35664 A1=camera_module_cache_ram_15__7
+ S0=nx36720
Xcamera_module_cache_reg_ram_31__7 dffr $PINS Q=camera_module_cache_ram_31__7
+ QB=#dummy[2063] D=nx19393 CLK=clk R=rst
Xix19394 mux21_ni $PINS Y=nx19393 A0=nx35664 A1=camera_module_cache_ram_31__7
+ S0=nx36734
Xix33326 aoi22 $PINS Y=nx33325 A0=camera_module_cache_ram_47__7 A1=nx37204
+ B0=camera_module_cache_ram_63__7 B1=nx37206
Xcamera_module_cache_reg_ram_47__7 dffr $PINS Q=camera_module_cache_ram_47__7
+ QB=#dummy[2064] D=nx19383 CLK=clk R=rst
Xix19384 mux21_ni $PINS Y=nx19383 A0=nx35664 A1=camera_module_cache_ram_47__7
+ S0=nx36738
Xcamera_module_cache_reg_ram_63__7 dffr $PINS Q=camera_module_cache_ram_63__7
+ QB=#dummy[2065] D=nx19373 CLK=clk R=rst
Xix19374 mux21_ni $PINS Y=nx19373 A0=nx35664 A1=camera_module_cache_ram_63__7
+ S0=nx36742
Xix33334 aoi22 $PINS Y=nx33333 A0=camera_module_cache_ram_79__7 A1=nx37208
+ B0=camera_module_cache_ram_95__7 B1=nx37210
Xcamera_module_cache_reg_ram_79__7 dffr $PINS Q=camera_module_cache_ram_79__7
+ QB=#dummy[2066] D=nx19363 CLK=clk R=rst
Xix19364 mux21_ni $PINS Y=nx19363 A0=nx35664 A1=camera_module_cache_ram_79__7
+ S0=nx36746
Xcamera_module_cache_reg_ram_95__7 dffr $PINS Q=camera_module_cache_ram_95__7
+ QB=#dummy[2067] D=nx19353 CLK=clk R=rst
Xix19354 mux21_ni $PINS Y=nx19353 A0=nx35666 A1=camera_module_cache_ram_95__7
+ S0=nx36750
Xix33342 aoi22 $PINS Y=nx33341 A0=camera_module_cache_ram_127__7 A1=nx37212
+ B0=camera_module_cache_ram_111__7 B1=nx37214
Xcamera_module_cache_reg_ram_127__7 dffr $PINS Q=camera_module_cache_ram_127__7
+ QB=#dummy[2068] D=nx19333 CLK=clk R=rst
Xix19334 mux21_ni $PINS Y=nx19333 A0=nx35666 A1=camera_module_cache_ram_127__7
+ S0=nx36754
Xcamera_module_cache_reg_ram_111__7 dffr $PINS Q=camera_module_cache_ram_111__7
+ QB=#dummy[2069] D=nx19343 CLK=clk R=rst
Xix19344 mux21_ni $PINS Y=nx19343 A0=nx35666 A1=camera_module_cache_ram_111__7
+ S0=nx36758
Xix22823 nand04 $PINS Y=nx22822 A0=nx33350 A1=nx33358 A2=nx33366 A3=nx33374
Xix33351 aoi22 $PINS Y=nx33350 A0=camera_module_cache_ram_143__7 A1=nx37216
+ B0=camera_module_cache_ram_159__7 B1=nx37218
Xcamera_module_cache_reg_ram_143__7 dffr $PINS Q=camera_module_cache_ram_143__7
+ QB=#dummy[2070] D=nx19323 CLK=clk R=rst
Xix19324 mux21_ni $PINS Y=nx19323 A0=nx35666 A1=camera_module_cache_ram_143__7
+ S0=nx36762
Xcamera_module_cache_reg_ram_159__7 dffr $PINS Q=camera_module_cache_ram_159__7
+ QB=#dummy[2071] D=nx19313 CLK=clk R=rst
Xix19314 mux21_ni $PINS Y=nx19313 A0=nx35666 A1=camera_module_cache_ram_159__7
+ S0=nx36766
Xix33359 aoi22 $PINS Y=nx33358 A0=camera_module_cache_ram_191__7 A1=nx37220
+ B0=camera_module_cache_ram_175__7 B1=nx37222
Xcamera_module_cache_reg_ram_191__7 dffr $PINS Q=camera_module_cache_ram_191__7
+ QB=#dummy[2072] D=nx19293 CLK=clk R=rst
Xix19294 mux21_ni $PINS Y=nx19293 A0=nx35666 A1=camera_module_cache_ram_191__7
+ S0=nx36770
Xcamera_module_cache_reg_ram_175__7 dffr $PINS Q=camera_module_cache_ram_175__7
+ QB=#dummy[2073] D=nx19303 CLK=clk R=rst
Xix19304 mux21_ni $PINS Y=nx19303 A0=nx35666 A1=camera_module_cache_ram_175__7
+ S0=nx36774
Xix33367 aoi22 $PINS Y=nx33366 A0=camera_module_cache_ram_207__7 A1=nx37224
+ B0=camera_module_cache_ram_223__7 B1=nx37226
Xcamera_module_cache_reg_ram_207__7 dffr $PINS Q=camera_module_cache_ram_207__7
+ QB=#dummy[2074] D=nx19283 CLK=clk R=rst
Xix19284 mux21_ni $PINS Y=nx19283 A0=nx35668 A1=camera_module_cache_ram_207__7
+ S0=nx36778
Xcamera_module_cache_reg_ram_223__7 dffr $PINS Q=camera_module_cache_ram_223__7
+ QB=#dummy[2075] D=nx19273 CLK=clk R=rst
Xix19274 mux21_ni $PINS Y=nx19273 A0=nx35668 A1=camera_module_cache_ram_223__7
+ S0=nx36782
Xix33375 aoi22 $PINS Y=nx33374 A0=camera_module_cache_ram_239__7 A1=nx37228
+ B0=camera_module_cache_ram_255__7 B1=nx37230
Xcamera_module_cache_reg_ram_239__7 dffr $PINS Q=camera_module_cache_ram_239__7
+ QB=#dummy[2076] D=nx19263 CLK=clk R=rst
Xix19264 mux21_ni $PINS Y=nx19263 A0=nx35668 A1=camera_module_cache_ram_239__7
+ S0=nx36786
Xcamera_module_cache_reg_ram_255__7 dffr $PINS Q=camera_module_cache_ram_255__7
+ QB=#dummy[2077] D=nx19253 CLK=clk R=rst
Xix19254 mux21_ni $PINS Y=nx19253 A0=nx35668 A1=camera_module_cache_ram_255__7
+ S0=nx36790
Xix33385 xnor2 $PINS Y=nx33384 A0=nx33386 A1=nx33472
Xix33387 aoi22 $PINS Y=nx33386 A0=zero A1=nx33388 B0=nx26320 B1=nx26324
Xix26321 oai22 $PINS Y=nx26320 A0=nx33391 A1=nx33465 B0=nx35680 B1=nx26248
Xix33392 aoi22 $PINS Y=nx33391 A0=zero A1=nx33393 B0=nx26172 B1=nx26176
Xix26173 oai22 $PINS Y=nx26172 A0=nx33396 A1=nx33458 B0=nx35678 B1=nx26100
Xix33397 aoi22 $PINS Y=nx33396 A0=zero A1=nx33398 B0=nx26024 B1=nx26028
Xix26025 oai22 $PINS Y=nx26024 A0=nx33401 A1=nx33451 B0=nx35678 B1=nx25952
Xix33402 aoi22 $PINS Y=nx33401 A0=zero A1=nx33403 B0=nx25876 B1=nx25880
Xix33406 xnor2 $PINS Y=nx33405 A0=camera_module_algo_module_pixel_value_6
+ A1=nx22699
Xix25877 oai22 $PINS Y=nx25876 A0=nx33408 A1=nx33444 B0=nx35678 B1=nx25804
Xix33409 aoi22 $PINS Y=nx33408 A0=zero A1=nx33410 B0=nx25728 B1=nx25732
Xix33413 xnor2 $PINS Y=nx33412 A0=camera_module_algo_module_pixel_value_4
+ A1=nx24945
Xix25729 oai22 $PINS Y=nx25728 A0=nx33415 A1=nx33437 B0=nx35678 B1=nx25656
Xix33416 aoi22 $PINS Y=nx33415 A0=nx25580 A1=nx25584 B0=zero B1=nx33435
Xix25581 oai22 $PINS Y=nx25580 A0=nx35678 A1=nx25508 B0=nx33419 B1=nx33427
Xix33420 aoi22 $PINS Y=nx33419 A0=one A1=nx25436 B0=zero B1=nx33425
Xix25437 xnor2 $PINS Y=nx25436 A0=zero A1=nx25434
Xix25435 xnor2 $PINS Y=nx25434 A0=one A1=nx33423
Xix33424 xnor2 $PINS Y=nx33423 A0=camera_module_algo_module_pixel_value_0
+ A1=nx27681
Xix33428 xnor2 $PINS Y=nx33427 A0=zero A1=nx33429
Xix33430 xnor2 $PINS Y=nx33429 A0=nx27676 A1=nx28817
Xix25585 xnor2 $PINS Y=nx25584 A0=zero A1=nx25582
Xix25583 xnor2 $PINS Y=nx25582 A0=nx8754 A1=nx33433
Xix33434 xnor2 $PINS Y=nx33433 A0=camera_module_algo_module_pixel_value_2
+ A1=nx26370
Xix33438 xnor2 $PINS Y=nx33437 A0=zero A1=nx33439
Xix33440 xnor2 $PINS Y=nx33439 A0=nx26363 A1=nx29959
Xix25733 xnor2 $PINS Y=nx25732 A0=zero A1=nx25730
Xix25731 xnor2 $PINS Y=nx25730 A0=nx14302 A1=nx33412
Xix33445 xnor2 $PINS Y=nx33444 A0=zero A1=nx33446
Xix33447 xnor2 $PINS Y=nx33446 A0=nx24939 A1=nx31101
Xix25881 xnor2 $PINS Y=nx25880 A0=zero A1=nx25878
Xix25879 xnor2 $PINS Y=nx25878 A0=nx19850 A1=nx33405
Xix33452 xnor2 $PINS Y=nx33451 A0=zero A1=nx33453
Xix33454 xnor2 $PINS Y=nx33453 A0=nx22693 A1=nx32243
Xix26029 xnor2 $PINS Y=nx26028 A0=zero A1=nx26026
Xix33459 xnor2 $PINS Y=nx33458 A0=zero A1=nx33460
Xix26177 xnor2 $PINS Y=nx26176 A0=zero A1=nx26174
Xix33466 xnor2 $PINS Y=nx33465 A0=zero A1=nx33467
Xix26325 xnor2 $PINS Y=nx26324 A0=zero A1=nx26322
Xix33473 xnor2 $PINS Y=nx33472 A0=zero A1=nx33474
Xcamera_module_algo_module_curr_cont_reg_reg_q_13 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_13 QB=nx33763 D=nx22203 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_13 dff $PINS
+ Q=camera_module_algo_module_Addout_value_13 QB=#dummy[2078] D=nx22193 CLK=clk
Xix26359 xnor2 $PINS Y=nx26358 A0=nx26356 A1=nx33760
Xix26357 oai22 $PINS Y=nx26356 A0=nx33485 A1=nx33739 B0=nx33753 B1=nx33750
Xix33486 aoi22 $PINS Y=nx33485 A0=camera_module_algo_module_diff_value_11
+ A1=camera_module_algo_module_current_cont_value_11 B0=nx26208 B1=nx929
Xcamera_module_algo_module_diff_reg_reg_q_11 dff $PINS
+ Q=camera_module_algo_module_diff_value_11 QB=nx33489 D=nx22153 CLK=clk
Xix33492 aoi21 $PINS Y=nx33491 A0=zero A1=nx34122 B0=nx26264
Xix26265 nor03_2x $PINS Y=nx26264 A0=nx34122 A1=nx35700 A2=nx33494
Xix33495 xnor2 $PINS Y=nx33494 A0=nx33391 A1=nx33465
Xcamera_module_algo_module_curr_cont_reg_reg_q_11 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_11 QB=nx33737 D=nx22143 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_11 dff $PINS
+ Q=camera_module_algo_module_Addout_value_11 QB=#dummy[2079] D=nx22133 CLK=clk
Xix26211 xnor2 $PINS Y=nx26210 A0=nx26208 A1=nx33734
Xix26209 oai22 $PINS Y=nx26208 A0=nx33504 A1=nx33713 B0=nx33727 B1=nx33724
Xix33505 aoi22 $PINS Y=nx33504 A0=camera_module_algo_module_diff_value_9
+ A1=camera_module_algo_module_current_cont_value_9 B0=nx26060 B1=nx925
Xcamera_module_algo_module_diff_reg_reg_q_9 dff $PINS
+ Q=camera_module_algo_module_diff_value_9 QB=nx33508 D=nx22093 CLK=clk
Xix33511 aoi21 $PINS Y=nx33510 A0=zero A1=nx34122 B0=nx26116
Xix26117 nor03_2x $PINS Y=nx26116 A0=nx34124 A1=nx35700 A2=nx33513
Xix33514 xnor2 $PINS Y=nx33513 A0=nx33396 A1=nx33458
Xcamera_module_algo_module_curr_cont_reg_reg_q_9 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_9 QB=nx33711 D=nx22083 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_9 dff $PINS
+ Q=camera_module_algo_module_Addout_value_9 QB=#dummy[2080] D=nx22073 CLK=clk
Xix26063 xnor2 $PINS Y=nx26062 A0=nx26060 A1=nx33708
Xix26061 oai22 $PINS Y=nx26060 A0=nx33523 A1=nx33690 B0=nx33707 B1=nx33701
Xix33524 aoi22 $PINS Y=nx33523 A0=camera_module_algo_module_diff_value_7
+ A1=camera_module_algo_module_current_cont_value_7 B0=nx25912 B1=nx921
Xcamera_module_algo_module_diff_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_diff_value_7 QB=#dummy[2081] D=nx22033 CLK=clk
Xix33530 xnor2 $PINS Y=nx33529 A0=nx33401 A1=nx33451
Xcamera_module_algo_module_curr_cont_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_7 QB=nx33688 D=nx22023 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_Addout_value_7 QB=#dummy[2082] D=nx22013 CLK=clk
Xix25915 xnor2 $PINS Y=nx25914 A0=nx25912 A1=nx33685
Xix25913 oai22 $PINS Y=nx25912 A0=nx33540 A1=nx33667 B0=nx33684 B1=nx33678
Xix33541 aoi22 $PINS Y=nx33540 A0=camera_module_algo_module_diff_value_5
+ A1=camera_module_algo_module_current_cont_value_5 B0=nx25764 B1=nx917
Xcamera_module_algo_module_diff_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_diff_value_5 QB=#dummy[2083] D=nx21973 CLK=clk
Xix33547 xnor2 $PINS Y=nx33546 A0=nx33408 A1=nx33444
Xcamera_module_algo_module_curr_cont_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_5 QB=nx33665 D=nx21963 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_Addout_value_5 QB=#dummy[2084] D=nx21953 CLK=clk
Xix25767 xnor2 $PINS Y=nx25766 A0=nx25764 A1=nx33662
Xix25765 oai22 $PINS Y=nx25764 A0=nx33557 A1=nx33644 B0=nx33661 B1=nx33655
Xix33558 aoi22 $PINS Y=nx33557 A0=camera_module_algo_module_diff_value_3
+ A1=camera_module_algo_module_current_cont_value_3 B0=nx25616 B1=nx913
Xcamera_module_algo_module_diff_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_diff_value_3 QB=#dummy[2085] D=nx21913 CLK=clk
Xix33564 xnor2 $PINS Y=nx33563 A0=nx33415 A1=nx33437
Xcamera_module_algo_module_curr_cont_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_3 QB=nx33642 D=nx21903 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_Addout_value_3 QB=#dummy[2086] D=nx21893 CLK=clk
Xix25619 xnor2 $PINS Y=nx25618 A0=nx25616 A1=nx33639
Xix25617 oai22 $PINS Y=nx25616 A0=nx33574 A1=nx33621 B0=nx33638 B1=nx33632
Xix33575 aoi22 $PINS Y=nx33574 A0=camera_module_algo_module_diff_value_1
+ A1=camera_module_algo_module_current_cont_value_1 B0=nx25468 B1=nx910
Xcamera_module_algo_module_diff_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_diff_value_1 QB=#dummy[2087] D=nx21853 CLK=clk
Xix33581 xnor2 $PINS Y=nx33580 A0=nx33419 A1=nx33427
Xcamera_module_algo_module_curr_cont_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_1 QB=nx33619 D=nx21843 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_Addout_value_1 QB=#dummy[2088] D=nx21833 CLK=clk
Xix25471 xnor2 $PINS Y=nx25470 A0=nx25468 A1=nx33616
Xix25469 oai22 $PINS Y=nx25468 A0=nx35680 A1=nx33591 B0=nx33615 B1=nx33609
Xcamera_module_algo_module_curr_cont_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_0 QB=nx33609 D=nx1243 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_Addout_value_0 QB=#dummy[2089] D=nx1233 CLK=clk
Xix657 xnor2 $PINS Y=nx656 A0=zero A1=nx33591
Xcamera_module_algo_module_modCU_reg_current_state_12 dff $PINS
+ Q=camera_module_algo_module_modCU_current_state_12 QB=nx33608 D=nx941 CLK=clk
Xix942 nor03_2x $PINS Y=nx941 A0=rst A1=nx22979 A2=nx35696
Xcamera_module_algo_module_diff_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_diff_value_0 QB=nx33615 D=nx21823 CLK=clk
Xix25439 xor2 $PINS Y=nx25438 A0=one A1=nx25436
Xcamera_module_algo_module_curr_cont_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_2 QB=nx33632 D=nx21873 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_Addout_value_2 QB=#dummy[2090] D=nx21863 CLK=clk
Xix33630 xnor2 $PINS Y=nx33629 A0=nx33574 A1=nx33621
Xcamera_module_algo_module_diff_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_diff_value_2 QB=nx33638 D=nx21883 CLK=clk
Xix25587 xor2 $PINS Y=nx25586 A0=nx25580 A1=nx25584
Xcamera_module_algo_module_curr_cont_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_4 QB=nx33655 D=nx21933 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_Addout_value_4 QB=#dummy[2091] D=nx21923 CLK=clk
Xix33653 xnor2 $PINS Y=nx33652 A0=nx33557 A1=nx33644
Xcamera_module_algo_module_diff_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_diff_value_4 QB=nx33661 D=nx21943 CLK=clk
Xix25735 xor2 $PINS Y=nx25734 A0=nx25728 A1=nx25732
Xcamera_module_algo_module_curr_cont_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_6 QB=nx33678 D=nx21993 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_Addout_value_6 QB=#dummy[2092] D=nx21983 CLK=clk
Xix33676 xnor2 $PINS Y=nx33675 A0=nx33540 A1=nx33667
Xcamera_module_algo_module_diff_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_diff_value_6 QB=nx33684 D=nx22003 CLK=clk
Xix25883 xor2 $PINS Y=nx25882 A0=nx25876 A1=nx25880
Xcamera_module_algo_module_curr_cont_reg_reg_q_8 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_8 QB=nx33701 D=nx22053 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_8 dff $PINS
+ Q=camera_module_algo_module_Addout_value_8 QB=#dummy[2093] D=nx22043 CLK=clk
Xix33699 xnor2 $PINS Y=nx33698 A0=nx33523 A1=nx33690
Xcamera_module_algo_module_diff_reg_reg_q_8 dff $PINS
+ Q=camera_module_algo_module_diff_value_8 QB=nx33707 D=nx22063 CLK=clk
Xix26031 xor2 $PINS Y=nx26030 A0=nx26024 A1=nx26028
Xcamera_module_algo_module_curr_cont_reg_reg_q_10 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_10 QB=nx33724 D=nx22113 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_10 dff $PINS
+ Q=camera_module_algo_module_Addout_value_10 QB=#dummy[2094] D=nx22103 CLK=clk
Xix33722 xnor2 $PINS Y=nx33721 A0=nx33504 A1=nx33713
Xcamera_module_algo_module_diff_reg_reg_q_10 dff $PINS Q=#dummy[2095]
+ QB=nx33727 D=nx22123 CLK=clk
Xix33730 aoi21 $PINS Y=nx33729 A0=zero A1=nx34130 B0=nx26190
Xix26191 nor03_2x $PINS Y=nx26190 A0=nx34130 A1=nx35702 A2=nx33732
Xix33733 xnor2 $PINS Y=nx33732 A0=nx26172 A1=nx26176
Xcamera_module_algo_module_curr_cont_reg_reg_q_12 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_12 QB=nx33750 D=nx22173 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_12 dff $PINS
+ Q=camera_module_algo_module_Addout_value_12 QB=#dummy[2096] D=nx22163 CLK=clk
Xix33748 xnor2 $PINS Y=nx33747 A0=nx33485 A1=nx33739
Xcamera_module_algo_module_diff_reg_reg_q_12 dff $PINS Q=#dummy[2097]
+ QB=nx33753 D=nx22183 CLK=clk
Xix33756 aoi21 $PINS Y=nx33755 A0=zero A1=nx34130 B0=nx26338
Xix26339 nor03_2x $PINS Y=nx26338 A0=nx34130 A1=nx35702 A2=nx33758
Xix33759 xnor2 $PINS Y=nx33758 A0=nx26320 A1=nx26324
Xcamera_module_algo_module_curr_cont_reg_reg_q_14 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_14 QB=nx33776 D=nx22233 CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_14 dff $PINS
+ Q=camera_module_algo_module_Addout_value_14 QB=#dummy[2098] D=nx22223 CLK=clk
Xix33774 xnor2 $PINS Y=nx33773 A0=nx22645 A1=nx33765
Xcamera_module_algo_module_diff_reg_reg_q_14 dff $PINS Q=#dummy[2099]
+ QB=nx33779 D=nx22243 CLK=clk
Xix33782 aoi21 $PINS Y=nx33781 A0=zero A1=nx34132 B0=nx26486
Xix26487 nor03_2x $PINS Y=nx26486 A0=nx34132 A1=nx35704 A2=nx33784
Xix33785 xnor2 $PINS Y=nx33784 A0=nx26468 A1=nx26472
Xix26469 oai22 $PINS Y=nx26468 A0=nx33386 A1=nx33472 B0=nx35682 B1=nx26396
Xix26473 xnor2 $PINS Y=nx26472 A0=zero A1=nx26470
Xcamera_module_algo_module_diff_reg_reg_q_15 dff $PINS
+ Q=camera_module_algo_module_diff_value_15 QB=nx33794 D=nx22253 CLK=clk
Xix33797 aoi21 $PINS Y=nx33796 A0=zero A1=nx34132 B0=nx26530
Xix26531 nor03_2x $PINS Y=nx26530 A0=nx34132 A1=nx35704 A2=nx33799
Xix33800 xnor2 $PINS Y=nx33799 A0=nx33801 A1=nx33805
Xix33802 aoi22 $PINS Y=nx33801 A0=zero A1=nx33803 B0=nx26468 B1=nx26472
Xix33806 xnor2 $PINS Y=nx33805 A0=zero A1=nx33807
Xcamera_module_algo_module_prev_cont_reg_reg_q_15 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_15 QB=#dummy[2100] D=nx22283
+ CLK=clk
Xix33817 aoi22 $PINS Y=nx33816
+ A0=camera_module_algo_module_current_cont_value_14 A1=nx33818 B0=nx26604
+ B1=nx26940
Xcamera_module_algo_module_prev_cont_reg_reg_q_14 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_14 QB=nx33818 D=nx22293 CLK=clk
Xix26941 oai22 $PINS Y=nx26940 A0=nx33825 A1=nx33832 B0=nx33763
+ B1=camera_module_algo_module_prev_cont_value_13
Xcamera_module_algo_module_prev_cont_reg_reg_q_13 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_13 QB=#dummy[2101] D=nx22303
+ CLK=clk
Xix33833 aoi22 $PINS Y=nx33832
+ A0=camera_module_algo_module_current_cont_value_12 A1=nx33834 B0=nx26636
+ B1=nx26924
Xcamera_module_algo_module_prev_cont_reg_reg_q_12 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_12 QB=nx33834 D=nx22313 CLK=clk
Xix26925 oai22 $PINS Y=nx26924 A0=nx33841 A1=nx33848 B0=nx33737
+ B1=camera_module_algo_module_prev_cont_value_11
Xcamera_module_algo_module_prev_cont_reg_reg_q_11 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_11 QB=#dummy[2102] D=nx22323
+ CLK=clk
Xix33849 aoi22 $PINS Y=nx33848
+ A0=camera_module_algo_module_current_cont_value_10 A1=nx33850 B0=nx26668
+ B1=nx26908
Xcamera_module_algo_module_prev_cont_reg_reg_q_10 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_10 QB=nx33850 D=nx22333 CLK=clk
Xix26909 oai22 $PINS Y=nx26908 A0=nx33857 A1=nx33864 B0=nx33711
+ B1=camera_module_algo_module_prev_cont_value_9
Xcamera_module_algo_module_prev_cont_reg_reg_q_9 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_9 QB=#dummy[2103] D=nx22343 CLK=clk
Xix33865 aoi22 $PINS Y=nx33864
+ A0=camera_module_algo_module_current_cont_value_8 A1=nx33866 B0=nx26700
+ B1=nx26892
Xcamera_module_algo_module_prev_cont_reg_reg_q_8 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_8 QB=nx33866 D=nx22353 CLK=clk
Xix26893 oai22 $PINS Y=nx26892 A0=nx33873 A1=nx33880 B0=nx33688
+ B1=camera_module_algo_module_prev_cont_value_7
Xcamera_module_algo_module_prev_cont_reg_reg_q_7 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_7 QB=#dummy[2104] D=nx22363 CLK=clk
Xix33881 aoi22 $PINS Y=nx33880
+ A0=camera_module_algo_module_current_cont_value_6 A1=nx33882 B0=nx26732
+ B1=nx26876
Xcamera_module_algo_module_prev_cont_reg_reg_q_6 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_6 QB=nx33882 D=nx22373 CLK=clk
Xix26877 oai22 $PINS Y=nx26876 A0=nx33889 A1=nx33896 B0=nx33665
+ B1=camera_module_algo_module_prev_cont_value_5
Xcamera_module_algo_module_prev_cont_reg_reg_q_5 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_5 QB=#dummy[2105] D=nx22383 CLK=clk
Xix33897 aoi22 $PINS Y=nx33896
+ A0=camera_module_algo_module_current_cont_value_4 A1=nx33898 B0=nx26764
+ B1=nx26860
Xcamera_module_algo_module_prev_cont_reg_reg_q_4 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_4 QB=nx33898 D=nx22393 CLK=clk
Xix26861 oai22 $PINS Y=nx26860 A0=nx33905 A1=nx33912 B0=nx33642
+ B1=camera_module_algo_module_prev_cont_value_3
Xcamera_module_algo_module_prev_cont_reg_reg_q_3 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_3 QB=#dummy[2106] D=nx22403 CLK=clk
Xix33913 aoi22 $PINS Y=nx33912
+ A0=camera_module_algo_module_current_cont_value_2 A1=nx33914 B0=nx26796
+ B1=nx26844
Xcamera_module_algo_module_prev_cont_reg_reg_q_2 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_2 QB=nx33914 D=nx22413 CLK=clk
Xix26845 oai22 $PINS Y=nx26844 A0=nx33921 A1=nx33928 B0=nx33619
+ B1=camera_module_algo_module_prev_cont_value_1
Xcamera_module_algo_module_prev_cont_reg_reg_q_1 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_1 QB=#dummy[2107] D=nx22423 CLK=clk
Xix33929 aoi22 $PINS Y=nx33928
+ A0=camera_module_algo_module_current_cont_value_0 A1=nx33930 B0=one B1=nx26828
Xcamera_module_algo_module_prev_cont_reg_reg_q_0 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_0 QB=nx33930 D=nx22433 CLK=clk
Xix27039 xnor2 $PINS Y=nx27038
+ A0=camera_module_algo_module_current_cont_value_16
+ A1=camera_module_algo_module_prev_cont_value_16
Xcamera_module_algo_module_curr_cont_reg_reg_q_16 dff $PINS
+ Q=camera_module_algo_module_current_cont_value_16 QB=#dummy[2108] D=nx22463
+ CLK=clk
Xcamera_module_algo_module_Addout_reg_reg_q_16 dff $PINS
+ Q=camera_module_algo_module_Addout_value_16 QB=#dummy[2109] D=nx22453 CLK=clk
Xix33944 xnor2 $PINS Y=nx33943 A0=nx33945 A1=nx33948
Xix33946 aoi22 $PINS Y=nx33945 A0=camera_module_algo_module_diff_value_15
+ A1=camera_module_algo_module_current_cont_value_15 B0=nx26504 B1=nx26542
Xix33949 xnor2 $PINS Y=nx33948
+ A0=camera_module_algo_module_current_cont_value_16
+ A1=camera_module_algo_module_diff_value_16
Xcamera_module_algo_module_diff_reg_reg_q_16 dff $PINS
+ Q=camera_module_algo_module_diff_value_16 QB=#dummy[2110] D=nx22443 CLK=clk
Xix26985 oai21 $PINS Y=nx26984 A0=nx35682 A1=nx35686 B0=nx33953
Xix33954 nand03 $PINS Y=nx33953 A0=nx26974 A1=nx35686 A2=nx37090
Xix26975 xnor2 $PINS Y=nx26974 A0=nx26970 A1=nx33958
Xix26971 oai22 $PINS Y=nx26970 A0=nx33801 A1=nx33805 B0=nx35682 B1=nx26514
Xcamera_module_algo_module_prev_cont_reg_reg_q_16 dff $PINS
+ Q=camera_module_algo_module_prev_cont_value_16 QB=#dummy[2111] D=nx22473
+ CLK=clk
Xix27133 nand04 $PINS Y=nx27132 A0=nx34003 A1=nx34005 A2=nx37118 A3=nx34010
Xix34006 nand03 $PINS Y=nx34005 A0=motor_move A1=motor_done A2=nx35694
Xix34011 nor04 $PINS Y=nx34010 A0=nx27122 A1=done A2=rst A3=nx883
Xix27123 aoi21 $PINS Y=nx27122 A0=nx22844 A1=nx35694 B0=nx22611
Xcamera_module_algo_module_modCU_reg_current_state_17 dff $PINS Q=done
+ QB=#dummy[2112] D=nx22533 CLK=clk
Xix22534 ao32 $PINS Y=nx22533
+ A0=camera_module_algo_module_modCU_current_state_14 A1=nx35694
+ A2=camera_module_algo_module_failure_count_value_0 B0=done B1=nx35696
Xix27121 nor02_2x $PINS Y=nx883 A0=rst A1=nx22613
Xix34019 nor03_2x $PINS Y=nx34018 A0=nx686 A1=nx37082
+ A2=camera_module_algo_module_modCU_current_state_12
Xix34028 nor02_2x $PINS Y=nx34027 A0=done A1=rst
Xix27157 nand02 $PINS Y=nx27156 A0=nx22627 A1=nx35686
Xix26543 inv01 $PINS Y=nx26542 A=nx33790
Xix26515 inv01 $PINS Y=nx26514 A=nx33807
Xix33804 inv01 $PINS Y=nx33803 A=nx26470
Xix26397 inv01 $PINS Y=nx26396 A=nx33474
Xix26425 inv01 $PINS Y=nx933 A=nx33760
Xix33389 inv01 $PINS Y=nx33388 A=nx26322
Xix26249 inv01 $PINS Y=nx26248 A=nx33467
Xix26277 inv01 $PINS Y=nx929 A=nx33734
Xix33394 inv01 $PINS Y=nx33393 A=nx26174
Xix26101 inv01 $PINS Y=nx26100 A=nx33460
Xix26129 inv01 $PINS Y=nx925 A=nx33708
Xix33399 inv01 $PINS Y=nx33398 A=nx26026
Xix25953 inv01 $PINS Y=nx25952 A=nx33453
Xix25981 inv01 $PINS Y=nx921 A=nx33685
Xix33404 inv01 $PINS Y=nx33403 A=nx25878
Xix25805 inv01 $PINS Y=nx25804 A=nx33446
Xix25833 inv01 $PINS Y=nx917 A=nx33662
Xix33411 inv01 $PINS Y=nx33410 A=nx25730
Xix25657 inv01 $PINS Y=nx25656 A=nx33439
Xix25685 inv01 $PINS Y=nx913 A=nx33639
Xix33436 inv01 $PINS Y=nx33435 A=nx25582
Xix25509 inv01 $PINS Y=nx25508 A=nx33429
Xix25537 inv01 $PINS Y=nx910 A=nx33616
Xix33426 inv01 $PINS Y=nx33425 A=nx25434
Xix25375 inv01 $PINS Y=nx25374 A=nx32248
Xix22617 inv01 $PINS Y=nx22616 A=nx33405
Xix19827 inv01 $PINS Y=nx19826 A=nx31106
Xix17069 inv01 $PINS Y=nx17068 A=nx33412
Xix14279 inv01 $PINS Y=nx14278 A=nx29964
Xix11521 inv01 $PINS Y=nx11520 A=nx33433
Xix8731 inv01 $PINS Y=nx8730 A=nx28822
Xix5973 inv01 $PINS Y=nx5972 A=nx33423
Xix23158 inv01 $PINS Y=nx23157 A=nx986
Xix935 inv01 $PINS Y=nx934 A=nx23079
Xix23530 inv01 $PINS Y=nx23529 A=nx842
Xix705 inv01 $PINS Y=nx704 A=nx22679
Xix585 inv01 $PINS Y=nx908 A=nx23033
Xix537 inv01 $PINS Y=nx905 A=nx23006
Xix479 inv01 $PINS Y=nx903 A=nx22951
Xix409 inv01 $PINS Y=nx408 A=nx22579
Xix405 inv01 $PINS Y=nx404 A=nx22953
Xix235 inv01 $PINS Y=nx897 A=nx22827
Xix129 inv01 $PINS Y=nx128 A=nx22849
Xix97 inv01 $PINS Y=nx889 A=nx22811
Xix34035 inv02 $PINS Y=nx34036 A=nx35698
Xix34037 inv02 $PINS Y=nx34038 A=nx35698
Xix34039 inv02 $PINS Y=nx34040 A=nx37172
Xix34041 inv02 $PINS Y=nx34042 A=nx37172
Xix34065 inv02 $PINS Y=nx34066 A=nx37124
Xix34067 inv02 $PINS Y=nx34068 A=nx37124
Xix34069 inv02 $PINS Y=nx34070 A=nx37124
Xix34071 inv02 $PINS Y=nx34072 A=nx22719
Xix34073 inv02 $PINS Y=nx34074 A=nx22719
Xix34075 inv02 $PINS Y=nx34076 A=nx22719
Xix34079 inv02 $PINS Y=nx34080 A=nx37156
Xix34081 inv02 $PINS Y=nx34082 A=nx37156
Xix34083 inv02 $PINS Y=nx34084 A=nx37156
Xix34085 inv02 $PINS Y=nx34086 A=nx37156
Xix34089 inv02 $PINS Y=nx34090 A=nx37164
Xix34091 inv02 $PINS Y=nx34092 A=nx37164
Xix34093 inv02 $PINS Y=nx34094 A=nx37164
Xix34095 inv02 $PINS Y=nx34096 A=nx37164
Xix34097 inv02 $PINS Y=nx34098 A=nx22757
Xix34099 inv02 $PINS Y=nx34100 A=nx37096
Xix34101 inv02 $PINS Y=nx34102 A=nx37096
Xix34103 inv02 $PINS Y=nx34104 A=nx37096
Xix34105 inv02 $PINS Y=nx34106 A=nx37096
Xix34107 inv02 $PINS Y=nx34108 A=nx37096
Xix34109 inv02 $PINS Y=nx34110 A=nx37096
Xix34111 inv02 $PINS Y=nx34112 A=nx22771
Xix34117 inv02 $PINS Y=nx34118 A=nx37136
Xix34119 inv02 $PINS Y=nx34120 A=nx37136
Xix34121 inv02 $PINS Y=nx34122 A=nx37136
Xix34123 inv02 $PINS Y=nx34124 A=nx37136
Xix34129 inv02 $PINS Y=nx34130 A=nx37136
Xix34131 inv02 $PINS Y=nx34132 A=nx37146
Xix34137 inv02 $PINS Y=nx34138 A=nx37146
Xix34139 inv04 $PINS Y=nx34140 A=nx37196
Xix34141 inv04 $PINS Y=nx34142 A=nx35784
Xix34163 inv02 $PINS Y=nx34164 A=nx36804
Xix34165 inv02 $PINS Y=nx34166 A=nx36804
Xix34167 inv02 $PINS Y=nx34168 A=nx36804
Xix34169 inv02 $PINS Y=nx34170 A=nx36804
Xix34171 inv02 $PINS Y=nx34172 A=nx36804
Xix34173 inv02 $PINS Y=nx34174 A=nx36804
Xix34175 inv02 $PINS Y=nx34176 A=nx36804
Xix34177 inv02 $PINS Y=nx34178 A=nx36806
Xix34179 inv02 $PINS Y=nx34180 A=nx36806
Xix34181 inv02 $PINS Y=nx34182 A=nx36806
Xix34183 inv02 $PINS Y=nx34184 A=nx36806
Xix34185 inv02 $PINS Y=nx34186 A=nx36806
Xix34187 inv02 $PINS Y=nx34188 A=nx36806
Xix34189 inv02 $PINS Y=nx34190 A=nx36806
Xix34191 inv02 $PINS Y=nx34192 A=nx36808
Xix34193 inv02 $PINS Y=nx34194 A=nx36808
Xix34195 inv02 $PINS Y=nx34196 A=nx36808
Xix34197 inv02 $PINS Y=nx34198 A=nx36808
Xix34199 inv02 $PINS Y=nx34200 A=nx36808
Xix34201 inv02 $PINS Y=nx34202 A=nx36808
Xix34203 inv02 $PINS Y=nx34204 A=nx36808
Xix34205 inv02 $PINS Y=nx34206 A=nx36810
Xix34207 inv02 $PINS Y=nx34208 A=nx36810
Xix34209 inv02 $PINS Y=nx34210 A=nx36810
Xix34211 inv02 $PINS Y=nx34212 A=nx36810
Xix34213 inv02 $PINS Y=nx34214 A=nx36810
Xix34215 inv02 $PINS Y=nx34216 A=nx36810
Xix34217 inv02 $PINS Y=nx34218 A=nx36810
Xix34219 inv02 $PINS Y=nx34220 A=nx36812
Xix34221 inv02 $PINS Y=nx34222 A=nx36812
Xix34223 inv02 $PINS Y=nx34224 A=nx36812
Xix34225 inv02 $PINS Y=nx34226 A=nx36812
Xix34227 inv02 $PINS Y=nx34228 A=nx36812
Xix34229 inv02 $PINS Y=nx34230 A=nx36812
Xix34231 inv02 $PINS Y=nx34232 A=nx36812
Xix34233 inv02 $PINS Y=nx34234 A=nx36814
Xix34235 inv02 $PINS Y=nx34236 A=nx36814
Xix34303 buf02 $PINS Y=nx34304 A=nx2424
Xix34305 buf02 $PINS Y=nx34306 A=nx2424
Xix34307 buf02 $PINS Y=nx34308 A=nx2440
Xix34309 buf02 $PINS Y=nx34310 A=nx2440
Xix34311 buf02 $PINS Y=nx34312 A=nx2458
Xix34313 buf02 $PINS Y=nx34314 A=nx2458
Xix34315 buf02 $PINS Y=nx34316 A=nx2474
Xix34317 buf02 $PINS Y=nx34318 A=nx2474
Xix34319 buf02 $PINS Y=nx34320 A=nx2494
Xix34321 buf02 $PINS Y=nx34322 A=nx2494
Xix34323 buf02 $PINS Y=nx34324 A=nx2510
Xix34325 buf02 $PINS Y=nx34326 A=nx2510
Xix34327 buf02 $PINS Y=nx34328 A=nx2528
Xix34329 buf02 $PINS Y=nx34330 A=nx2528
Xix34331 buf02 $PINS Y=nx34332 A=nx2544
Xix34333 buf02 $PINS Y=nx34334 A=nx2544
Xix34335 buf02 $PINS Y=nx34336 A=nx2566
Xix34337 buf02 $PINS Y=nx34338 A=nx2566
Xix34339 buf02 $PINS Y=nx34340 A=nx2582
Xix34341 buf02 $PINS Y=nx34342 A=nx2582
Xix34343 buf02 $PINS Y=nx34344 A=nx2600
Xix34345 buf02 $PINS Y=nx34346 A=nx2600
Xix34347 buf02 $PINS Y=nx34348 A=nx2616
Xix34349 buf02 $PINS Y=nx34350 A=nx2616
Xix34351 buf02 $PINS Y=nx34352 A=nx2636
Xix34353 buf02 $PINS Y=nx34354 A=nx2636
Xix34355 buf02 $PINS Y=nx34356 A=nx2652
Xix34357 buf02 $PINS Y=nx34358 A=nx2652
Xix34359 buf02 $PINS Y=nx34360 A=nx2670
Xix34361 buf02 $PINS Y=nx34362 A=nx2670
Xix34363 buf02 $PINS Y=nx34364 A=nx2686
Xix34365 buf02 $PINS Y=nx34366 A=nx2686
Xix34373 buf02 $PINS Y=nx34374 A=nx2716
Xix34375 buf02 $PINS Y=nx34376 A=nx2716
Xix34377 buf02 $PINS Y=nx34378 A=nx2732
Xix34379 buf02 $PINS Y=nx34380 A=nx2732
Xix34381 buf02 $PINS Y=nx34382 A=nx2750
Xix34383 buf02 $PINS Y=nx34384 A=nx2750
Xix34385 buf02 $PINS Y=nx34386 A=nx2766
Xix34387 buf02 $PINS Y=nx34388 A=nx2766
Xix34389 buf02 $PINS Y=nx34390 A=nx2786
Xix34391 buf02 $PINS Y=nx34392 A=nx2786
Xix34393 buf02 $PINS Y=nx34394 A=nx2802
Xix34395 buf02 $PINS Y=nx34396 A=nx2802
Xix34397 buf02 $PINS Y=nx34398 A=nx2820
Xix34399 buf02 $PINS Y=nx34400 A=nx2820
Xix34401 buf02 $PINS Y=nx34402 A=nx2836
Xix34403 buf02 $PINS Y=nx34404 A=nx2836
Xix34405 buf02 $PINS Y=nx34406 A=nx2858
Xix34407 buf02 $PINS Y=nx34408 A=nx2858
Xix34409 buf02 $PINS Y=nx34410 A=nx2874
Xix34411 buf02 $PINS Y=nx34412 A=nx2874
Xix34413 buf02 $PINS Y=nx34414 A=nx2892
Xix34415 buf02 $PINS Y=nx34416 A=nx2892
Xix34417 buf02 $PINS Y=nx34418 A=nx2908
Xix34419 buf02 $PINS Y=nx34420 A=nx2908
Xix34421 buf02 $PINS Y=nx34422 A=nx2928
Xix34423 buf02 $PINS Y=nx34424 A=nx2928
Xix34425 buf02 $PINS Y=nx34426 A=nx2944
Xix34427 buf02 $PINS Y=nx34428 A=nx2944
Xix34429 buf02 $PINS Y=nx34430 A=nx2962
Xix34431 buf02 $PINS Y=nx34432 A=nx2962
Xix34433 buf02 $PINS Y=nx34434 A=nx2978
Xix34435 buf02 $PINS Y=nx34436 A=nx2978
Xix34443 buf02 $PINS Y=nx34444 A=nx3010
Xix34445 buf02 $PINS Y=nx34446 A=nx3010
Xix34447 buf02 $PINS Y=nx34448 A=nx3026
Xix34449 buf02 $PINS Y=nx34450 A=nx3026
Xix34451 buf02 $PINS Y=nx34452 A=nx3044
Xix34453 buf02 $PINS Y=nx34454 A=nx3044
Xix34455 buf02 $PINS Y=nx34456 A=nx3060
Xix34457 buf02 $PINS Y=nx34458 A=nx3060
Xix34459 buf02 $PINS Y=nx34460 A=nx3080
Xix34461 buf02 $PINS Y=nx34462 A=nx3080
Xix34463 buf02 $PINS Y=nx34464 A=nx3096
Xix34465 buf02 $PINS Y=nx34466 A=nx3096
Xix34467 buf02 $PINS Y=nx34468 A=nx3114
Xix34469 buf02 $PINS Y=nx34470 A=nx3114
Xix34471 buf02 $PINS Y=nx34472 A=nx3130
Xix34473 buf02 $PINS Y=nx34474 A=nx3130
Xix34475 buf02 $PINS Y=nx34476 A=nx3152
Xix34477 buf02 $PINS Y=nx34478 A=nx3152
Xix34479 buf02 $PINS Y=nx34480 A=nx3168
Xix34481 buf02 $PINS Y=nx34482 A=nx3168
Xix34483 buf02 $PINS Y=nx34484 A=nx3186
Xix34485 buf02 $PINS Y=nx34486 A=nx3186
Xix34487 buf02 $PINS Y=nx34488 A=nx3202
Xix34489 buf02 $PINS Y=nx34490 A=nx3202
Xix34491 buf02 $PINS Y=nx34492 A=nx3222
Xix34493 buf02 $PINS Y=nx34494 A=nx3222
Xix34495 buf02 $PINS Y=nx34496 A=nx3238
Xix34497 buf02 $PINS Y=nx34498 A=nx3238
Xix34499 buf02 $PINS Y=nx34500 A=nx3256
Xix34501 buf02 $PINS Y=nx34502 A=nx3256
Xix34503 buf02 $PINS Y=nx34504 A=nx3272
Xix34505 buf02 $PINS Y=nx34506 A=nx3272
Xix34513 buf02 $PINS Y=nx34514 A=nx3302
Xix34515 buf02 $PINS Y=nx34516 A=nx3302
Xix34517 buf02 $PINS Y=nx34518 A=nx3318
Xix34519 buf02 $PINS Y=nx34520 A=nx3318
Xix34521 buf02 $PINS Y=nx34522 A=nx3336
Xix34523 buf02 $PINS Y=nx34524 A=nx3336
Xix34525 buf02 $PINS Y=nx34526 A=nx3352
Xix34527 buf02 $PINS Y=nx34528 A=nx3352
Xix34529 buf02 $PINS Y=nx34530 A=nx3372
Xix34531 buf02 $PINS Y=nx34532 A=nx3372
Xix34533 buf02 $PINS Y=nx34534 A=nx3388
Xix34535 buf02 $PINS Y=nx34536 A=nx3388
Xix34537 buf02 $PINS Y=nx34538 A=nx3406
Xix34539 buf02 $PINS Y=nx34540 A=nx3406
Xix34541 buf02 $PINS Y=nx34542 A=nx3422
Xix34543 buf02 $PINS Y=nx34544 A=nx3422
Xix34545 buf02 $PINS Y=nx34546 A=nx3444
Xix34547 buf02 $PINS Y=nx34548 A=nx3444
Xix34549 buf02 $PINS Y=nx34550 A=nx3460
Xix34551 buf02 $PINS Y=nx34552 A=nx3460
Xix34553 buf02 $PINS Y=nx34554 A=nx3478
Xix34555 buf02 $PINS Y=nx34556 A=nx3478
Xix34557 buf02 $PINS Y=nx34558 A=nx3494
Xix34559 buf02 $PINS Y=nx34560 A=nx3494
Xix34561 buf02 $PINS Y=nx34562 A=nx3514
Xix34563 buf02 $PINS Y=nx34564 A=nx3514
Xix34565 buf02 $PINS Y=nx34566 A=nx3530
Xix34567 buf02 $PINS Y=nx34568 A=nx3530
Xix34569 buf02 $PINS Y=nx34570 A=nx3548
Xix34571 buf02 $PINS Y=nx34572 A=nx3548
Xix34573 buf02 $PINS Y=nx34574 A=nx3564
Xix34575 buf02 $PINS Y=nx34576 A=nx3564
Xix34583 buf02 $PINS Y=nx34584 A=nx3604
Xix34585 buf02 $PINS Y=nx34586 A=nx3604
Xix34587 buf02 $PINS Y=nx34588 A=nx3620
Xix34589 buf02 $PINS Y=nx34590 A=nx3620
Xix34591 buf02 $PINS Y=nx34592 A=nx3638
Xix34593 buf02 $PINS Y=nx34594 A=nx3638
Xix34595 buf02 $PINS Y=nx34596 A=nx3654
Xix34597 buf02 $PINS Y=nx34598 A=nx3654
Xix34599 buf02 $PINS Y=nx34600 A=nx3674
Xix34601 buf02 $PINS Y=nx34602 A=nx3674
Xix34603 buf02 $PINS Y=nx34604 A=nx3690
Xix34605 buf02 $PINS Y=nx34606 A=nx3690
Xix34607 buf02 $PINS Y=nx34608 A=nx3708
Xix34609 buf02 $PINS Y=nx34610 A=nx3708
Xix34611 buf02 $PINS Y=nx34612 A=nx3724
Xix34613 buf02 $PINS Y=nx34614 A=nx3724
Xix34615 buf02 $PINS Y=nx34616 A=nx3746
Xix34617 buf02 $PINS Y=nx34618 A=nx3746
Xix34619 buf02 $PINS Y=nx34620 A=nx3762
Xix34621 buf02 $PINS Y=nx34622 A=nx3762
Xix34623 buf02 $PINS Y=nx34624 A=nx3780
Xix34625 buf02 $PINS Y=nx34626 A=nx3780
Xix34627 buf02 $PINS Y=nx34628 A=nx3796
Xix34629 buf02 $PINS Y=nx34630 A=nx3796
Xix34631 buf02 $PINS Y=nx34632 A=nx3816
Xix34633 buf02 $PINS Y=nx34634 A=nx3816
Xix34635 buf02 $PINS Y=nx34636 A=nx3832
Xix34637 buf02 $PINS Y=nx34638 A=nx3832
Xix34639 buf02 $PINS Y=nx34640 A=nx3850
Xix34641 buf02 $PINS Y=nx34642 A=nx3850
Xix34643 buf02 $PINS Y=nx34644 A=nx3866
Xix34645 buf02 $PINS Y=nx34646 A=nx3866
Xix34653 buf02 $PINS Y=nx34654 A=nx3896
Xix34655 buf02 $PINS Y=nx34656 A=nx3896
Xix34657 buf02 $PINS Y=nx34658 A=nx3912
Xix34659 buf02 $PINS Y=nx34660 A=nx3912
Xix34661 buf02 $PINS Y=nx34662 A=nx3930
Xix34663 buf02 $PINS Y=nx34664 A=nx3930
Xix34665 buf02 $PINS Y=nx34666 A=nx3946
Xix34667 buf02 $PINS Y=nx34668 A=nx3946
Xix34669 buf02 $PINS Y=nx34670 A=nx3966
Xix34671 buf02 $PINS Y=nx34672 A=nx3966
Xix34673 buf02 $PINS Y=nx34674 A=nx3982
Xix34675 buf02 $PINS Y=nx34676 A=nx3982
Xix34677 buf02 $PINS Y=nx34678 A=nx4000
Xix34679 buf02 $PINS Y=nx34680 A=nx4000
Xix34681 buf02 $PINS Y=nx34682 A=nx4016
Xix34683 buf02 $PINS Y=nx34684 A=nx4016
Xix34685 buf02 $PINS Y=nx34686 A=nx4038
Xix34687 buf02 $PINS Y=nx34688 A=nx4038
Xix34689 buf02 $PINS Y=nx34690 A=nx4054
Xix34691 buf02 $PINS Y=nx34692 A=nx4054
Xix34693 buf02 $PINS Y=nx34694 A=nx4072
Xix34695 buf02 $PINS Y=nx34696 A=nx4072
Xix34697 buf02 $PINS Y=nx34698 A=nx4088
Xix34699 buf02 $PINS Y=nx34700 A=nx4088
Xix34701 buf02 $PINS Y=nx34702 A=nx4108
Xix34703 buf02 $PINS Y=nx34704 A=nx4108
Xix34705 buf02 $PINS Y=nx34706 A=nx4124
Xix34707 buf02 $PINS Y=nx34708 A=nx4124
Xix34709 buf02 $PINS Y=nx34710 A=nx4142
Xix34711 buf02 $PINS Y=nx34712 A=nx4142
Xix34713 buf02 $PINS Y=nx34714 A=nx4158
Xix34715 buf02 $PINS Y=nx34716 A=nx4158
Xix34723 buf02 $PINS Y=nx34724 A=nx4190
Xix34725 buf02 $PINS Y=nx34726 A=nx4190
Xix34727 buf02 $PINS Y=nx34728 A=nx4206
Xix34729 buf02 $PINS Y=nx34730 A=nx4206
Xix34731 buf02 $PINS Y=nx34732 A=nx4224
Xix34733 buf02 $PINS Y=nx34734 A=nx4224
Xix34735 buf02 $PINS Y=nx34736 A=nx4240
Xix34737 buf02 $PINS Y=nx34738 A=nx4240
Xix34739 buf02 $PINS Y=nx34740 A=nx4260
Xix34741 buf02 $PINS Y=nx34742 A=nx4260
Xix34743 buf02 $PINS Y=nx34744 A=nx4276
Xix34745 buf02 $PINS Y=nx34746 A=nx4276
Xix34747 buf02 $PINS Y=nx34748 A=nx4294
Xix34749 buf02 $PINS Y=nx34750 A=nx4294
Xix34751 buf02 $PINS Y=nx34752 A=nx4310
Xix34753 buf02 $PINS Y=nx34754 A=nx4310
Xix34755 buf02 $PINS Y=nx34756 A=nx4332
Xix34757 buf02 $PINS Y=nx34758 A=nx4332
Xix34759 buf02 $PINS Y=nx34760 A=nx4348
Xix34761 buf02 $PINS Y=nx34762 A=nx4348
Xix34763 buf02 $PINS Y=nx34764 A=nx4366
Xix34765 buf02 $PINS Y=nx34766 A=nx4366
Xix34767 buf02 $PINS Y=nx34768 A=nx4382
Xix34769 buf02 $PINS Y=nx34770 A=nx4382
Xix34771 buf02 $PINS Y=nx34772 A=nx4402
Xix34773 buf02 $PINS Y=nx34774 A=nx4402
Xix34775 buf02 $PINS Y=nx34776 A=nx4418
Xix34777 buf02 $PINS Y=nx34778 A=nx4418
Xix34779 buf02 $PINS Y=nx34780 A=nx4436
Xix34781 buf02 $PINS Y=nx34782 A=nx4436
Xix34783 buf02 $PINS Y=nx34784 A=nx4452
Xix34785 buf02 $PINS Y=nx34786 A=nx4452
Xix34793 buf02 $PINS Y=nx34794 A=nx4482
Xix34795 buf02 $PINS Y=nx34796 A=nx4482
Xix34797 buf02 $PINS Y=nx34798 A=nx4498
Xix34799 buf02 $PINS Y=nx34800 A=nx4498
Xix34801 buf02 $PINS Y=nx34802 A=nx4516
Xix34803 buf02 $PINS Y=nx34804 A=nx4516
Xix34805 buf02 $PINS Y=nx34806 A=nx4532
Xix34807 buf02 $PINS Y=nx34808 A=nx4532
Xix34809 buf02 $PINS Y=nx34810 A=nx4552
Xix34811 buf02 $PINS Y=nx34812 A=nx4552
Xix34813 buf02 $PINS Y=nx34814 A=nx4568
Xix34815 buf02 $PINS Y=nx34816 A=nx4568
Xix34817 buf02 $PINS Y=nx34818 A=nx4586
Xix34819 buf02 $PINS Y=nx34820 A=nx4586
Xix34821 buf02 $PINS Y=nx34822 A=nx4602
Xix34823 buf02 $PINS Y=nx34824 A=nx4602
Xix34825 buf02 $PINS Y=nx34826 A=nx4624
Xix34827 buf02 $PINS Y=nx34828 A=nx4624
Xix34829 buf02 $PINS Y=nx34830 A=nx4640
Xix34831 buf02 $PINS Y=nx34832 A=nx4640
Xix34833 buf02 $PINS Y=nx34834 A=nx4658
Xix34835 buf02 $PINS Y=nx34836 A=nx4658
Xix34837 buf02 $PINS Y=nx34838 A=nx4674
Xix34839 buf02 $PINS Y=nx34840 A=nx4674
Xix34841 buf02 $PINS Y=nx34842 A=nx4694
Xix34843 buf02 $PINS Y=nx34844 A=nx4694
Xix34845 buf02 $PINS Y=nx34846 A=nx4710
Xix34847 buf02 $PINS Y=nx34848 A=nx4710
Xix34849 buf02 $PINS Y=nx34850 A=nx4728
Xix34851 buf02 $PINS Y=nx34852 A=nx4728
Xix34853 buf02 $PINS Y=nx34854 A=nx4744
Xix34855 buf02 $PINS Y=nx34856 A=nx4744
Xix34863 buf02 $PINS Y=nx34864 A=nx4780
Xix34865 buf02 $PINS Y=nx34866 A=nx4780
Xix34867 buf02 $PINS Y=nx34868 A=nx4796
Xix34869 buf02 $PINS Y=nx34870 A=nx4796
Xix34871 buf02 $PINS Y=nx34872 A=nx4814
Xix34873 buf02 $PINS Y=nx34874 A=nx4814
Xix34875 buf02 $PINS Y=nx34876 A=nx4830
Xix34877 buf02 $PINS Y=nx34878 A=nx4830
Xix34879 buf02 $PINS Y=nx34880 A=nx4850
Xix34881 buf02 $PINS Y=nx34882 A=nx4850
Xix34883 buf02 $PINS Y=nx34884 A=nx4866
Xix34885 buf02 $PINS Y=nx34886 A=nx4866
Xix34887 buf02 $PINS Y=nx34888 A=nx4884
Xix34889 buf02 $PINS Y=nx34890 A=nx4884
Xix34891 buf02 $PINS Y=nx34892 A=nx4900
Xix34893 buf02 $PINS Y=nx34894 A=nx4900
Xix34895 buf02 $PINS Y=nx34896 A=nx4922
Xix34897 buf02 $PINS Y=nx34898 A=nx4922
Xix34899 buf02 $PINS Y=nx34900 A=nx4938
Xix34901 buf02 $PINS Y=nx34902 A=nx4938
Xix34903 buf02 $PINS Y=nx34904 A=nx4956
Xix34905 buf02 $PINS Y=nx34906 A=nx4956
Xix34907 buf02 $PINS Y=nx34908 A=nx4972
Xix34909 buf02 $PINS Y=nx34910 A=nx4972
Xix34911 buf02 $PINS Y=nx34912 A=nx4992
Xix34913 buf02 $PINS Y=nx34914 A=nx4992
Xix34915 buf02 $PINS Y=nx34916 A=nx5008
Xix34917 buf02 $PINS Y=nx34918 A=nx5008
Xix34919 buf02 $PINS Y=nx34920 A=nx5026
Xix34921 buf02 $PINS Y=nx34922 A=nx5026
Xix34923 buf02 $PINS Y=nx34924 A=nx5042
Xix34925 buf02 $PINS Y=nx34926 A=nx5042
Xix34933 buf02 $PINS Y=nx34934 A=nx5072
Xix34935 buf02 $PINS Y=nx34936 A=nx5072
Xix34937 buf02 $PINS Y=nx34938 A=nx5088
Xix34939 buf02 $PINS Y=nx34940 A=nx5088
Xix34941 buf02 $PINS Y=nx34942 A=nx5106
Xix34943 buf02 $PINS Y=nx34944 A=nx5106
Xix34945 buf02 $PINS Y=nx34946 A=nx5122
Xix34947 buf02 $PINS Y=nx34948 A=nx5122
Xix34949 buf02 $PINS Y=nx34950 A=nx5142
Xix34951 buf02 $PINS Y=nx34952 A=nx5142
Xix34953 buf02 $PINS Y=nx34954 A=nx5158
Xix34955 buf02 $PINS Y=nx34956 A=nx5158
Xix34957 buf02 $PINS Y=nx34958 A=nx5176
Xix34959 buf02 $PINS Y=nx34960 A=nx5176
Xix34961 buf02 $PINS Y=nx34962 A=nx5192
Xix34963 buf02 $PINS Y=nx34964 A=nx5192
Xix34965 buf02 $PINS Y=nx34966 A=nx5214
Xix34967 buf02 $PINS Y=nx34968 A=nx5214
Xix34969 buf02 $PINS Y=nx34970 A=nx5230
Xix34971 buf02 $PINS Y=nx34972 A=nx5230
Xix34973 buf02 $PINS Y=nx34974 A=nx5248
Xix34975 buf02 $PINS Y=nx34976 A=nx5248
Xix34977 buf02 $PINS Y=nx34978 A=nx5264
Xix34979 buf02 $PINS Y=nx34980 A=nx5264
Xix34981 buf02 $PINS Y=nx34982 A=nx5284
Xix34983 buf02 $PINS Y=nx34984 A=nx5284
Xix34985 buf02 $PINS Y=nx34986 A=nx5300
Xix34987 buf02 $PINS Y=nx34988 A=nx5300
Xix34989 buf02 $PINS Y=nx34990 A=nx5318
Xix34991 buf02 $PINS Y=nx34992 A=nx5318
Xix34993 buf02 $PINS Y=nx34994 A=nx5334
Xix34995 buf02 $PINS Y=nx34996 A=nx5334
Xix35003 buf02 $PINS Y=nx35004 A=nx5366
Xix35005 buf02 $PINS Y=nx35006 A=nx5366
Xix35007 buf02 $PINS Y=nx35008 A=nx5382
Xix35009 buf02 $PINS Y=nx35010 A=nx5382
Xix35011 buf02 $PINS Y=nx35012 A=nx5400
Xix35013 buf02 $PINS Y=nx35014 A=nx5400
Xix35015 buf02 $PINS Y=nx35016 A=nx5416
Xix35017 buf02 $PINS Y=nx35018 A=nx5416
Xix35019 buf02 $PINS Y=nx35020 A=nx5436
Xix35021 buf02 $PINS Y=nx35022 A=nx5436
Xix35023 buf02 $PINS Y=nx35024 A=nx5452
Xix35025 buf02 $PINS Y=nx35026 A=nx5452
Xix35027 buf02 $PINS Y=nx35028 A=nx5470
Xix35029 buf02 $PINS Y=nx35030 A=nx5470
Xix35031 buf02 $PINS Y=nx35032 A=nx5486
Xix35033 buf02 $PINS Y=nx35034 A=nx5486
Xix35035 buf02 $PINS Y=nx35036 A=nx5508
Xix35037 buf02 $PINS Y=nx35038 A=nx5508
Xix35039 buf02 $PINS Y=nx35040 A=nx5524
Xix35041 buf02 $PINS Y=nx35042 A=nx5524
Xix35043 buf02 $PINS Y=nx35044 A=nx5542
Xix35045 buf02 $PINS Y=nx35046 A=nx5542
Xix35047 buf02 $PINS Y=nx35048 A=nx5558
Xix35049 buf02 $PINS Y=nx35050 A=nx5558
Xix35051 buf02 $PINS Y=nx35052 A=nx5578
Xix35053 buf02 $PINS Y=nx35054 A=nx5578
Xix35055 buf02 $PINS Y=nx35056 A=nx5594
Xix35057 buf02 $PINS Y=nx35058 A=nx5594
Xix35059 buf02 $PINS Y=nx35060 A=nx5612
Xix35061 buf02 $PINS Y=nx35062 A=nx5612
Xix35063 buf02 $PINS Y=nx35064 A=nx5628
Xix35065 buf02 $PINS Y=nx35066 A=nx5628
Xix35073 buf02 $PINS Y=nx35074 A=nx5658
Xix35075 buf02 $PINS Y=nx35076 A=nx5658
Xix35077 buf02 $PINS Y=nx35078 A=nx5674
Xix35079 buf02 $PINS Y=nx35080 A=nx5674
Xix35081 buf02 $PINS Y=nx35082 A=nx5692
Xix35083 buf02 $PINS Y=nx35084 A=nx5692
Xix35085 buf02 $PINS Y=nx35086 A=nx5708
Xix35087 buf02 $PINS Y=nx35088 A=nx5708
Xix35089 buf02 $PINS Y=nx35090 A=nx5728
Xix35091 buf02 $PINS Y=nx35092 A=nx5728
Xix35093 buf02 $PINS Y=nx35094 A=nx5744
Xix35095 buf02 $PINS Y=nx35096 A=nx5744
Xix35097 buf02 $PINS Y=nx35098 A=nx5762
Xix35099 buf02 $PINS Y=nx35100 A=nx5762
Xix35101 buf02 $PINS Y=nx35102 A=nx5778
Xix35103 buf02 $PINS Y=nx35104 A=nx5778
Xix35105 buf02 $PINS Y=nx35106 A=nx5800
Xix35107 buf02 $PINS Y=nx35108 A=nx5800
Xix35109 buf02 $PINS Y=nx35110 A=nx5816
Xix35111 buf02 $PINS Y=nx35112 A=nx5816
Xix35113 buf02 $PINS Y=nx35114 A=nx5834
Xix35115 buf02 $PINS Y=nx35116 A=nx5834
Xix35117 buf02 $PINS Y=nx35118 A=nx5850
Xix35119 buf02 $PINS Y=nx35120 A=nx5850
Xix35121 buf02 $PINS Y=nx35122 A=nx5870
Xix35123 buf02 $PINS Y=nx35124 A=nx5870
Xix35125 buf02 $PINS Y=nx35126 A=nx5886
Xix35127 buf02 $PINS Y=nx35128 A=nx5886
Xix35129 buf02 $PINS Y=nx35130 A=nx5904
Xix35131 buf02 $PINS Y=nx35132 A=nx5904
Xix35133 buf02 $PINS Y=nx35134 A=nx5920
Xix35135 buf02 $PINS Y=nx35136 A=nx5920
Xix35139 inv02 $PINS Y=nx35140 A=nx36816
Xix35141 inv02 $PINS Y=nx35142 A=nx36816
Xix35143 inv02 $PINS Y=nx35144 A=nx36816
Xix35145 inv02 $PINS Y=nx35146 A=nx36816
Xix35147 inv02 $PINS Y=nx35148 A=nx36816
Xix35149 inv02 $PINS Y=nx35150 A=nx36816
Xix35151 inv02 $PINS Y=nx35152 A=nx36816
Xix35153 inv02 $PINS Y=nx35154 A=nx36818
Xix35155 inv02 $PINS Y=nx35156 A=nx36818
Xix35157 inv02 $PINS Y=nx35158 A=nx36818
Xix35159 inv02 $PINS Y=nx35160 A=nx36818
Xix35161 inv02 $PINS Y=nx35162 A=nx36818
Xix35163 inv02 $PINS Y=nx35164 A=nx36818
Xix35165 inv02 $PINS Y=nx35166 A=nx36818
Xix35167 inv02 $PINS Y=nx35168 A=nx36820
Xix35169 inv02 $PINS Y=nx35170 A=nx36820
Xix35171 inv02 $PINS Y=nx35172 A=nx36820
Xix35173 inv02 $PINS Y=nx35174 A=nx36820
Xix35175 inv02 $PINS Y=nx35176 A=nx36820
Xix35177 inv02 $PINS Y=nx35178 A=nx36820
Xix35179 inv02 $PINS Y=nx35180 A=nx36820
Xix35181 inv02 $PINS Y=nx35182 A=nx36822
Xix35183 inv02 $PINS Y=nx35184 A=nx36822
Xix35185 inv02 $PINS Y=nx35186 A=nx36822
Xix35187 inv02 $PINS Y=nx35188 A=nx36822
Xix35189 inv02 $PINS Y=nx35190 A=nx36822
Xix35191 inv02 $PINS Y=nx35192 A=nx36822
Xix35193 inv02 $PINS Y=nx35194 A=nx36822
Xix35195 inv02 $PINS Y=nx35196 A=nx36824
Xix35197 inv02 $PINS Y=nx35198 A=nx36824
Xix35199 inv02 $PINS Y=nx35200 A=nx36824
Xix35201 inv02 $PINS Y=nx35202 A=nx36824
Xix35203 inv02 $PINS Y=nx35204 A=nx36824
Xix35205 inv02 $PINS Y=nx35206 A=nx36824
Xix35207 inv02 $PINS Y=nx35208 A=nx36824
Xix35209 inv02 $PINS Y=nx35210 A=nx36826
Xix35211 inv02 $PINS Y=nx35212 A=nx36826
Xix35215 inv02 $PINS Y=nx35216 A=nx36828
Xix35217 inv02 $PINS Y=nx35218 A=nx36828
Xix35219 inv02 $PINS Y=nx35220 A=nx36828
Xix35221 inv02 $PINS Y=nx35222 A=nx36828
Xix35223 inv02 $PINS Y=nx35224 A=nx36828
Xix35225 inv02 $PINS Y=nx35226 A=nx36828
Xix35227 inv02 $PINS Y=nx35228 A=nx36828
Xix35229 inv02 $PINS Y=nx35230 A=nx36830
Xix35231 inv02 $PINS Y=nx35232 A=nx36830
Xix35233 inv02 $PINS Y=nx35234 A=nx36830
Xix35235 inv02 $PINS Y=nx35236 A=nx36830
Xix35237 inv02 $PINS Y=nx35238 A=nx36830
Xix35239 inv02 $PINS Y=nx35240 A=nx36830
Xix35241 inv02 $PINS Y=nx35242 A=nx36830
Xix35243 inv02 $PINS Y=nx35244 A=nx36832
Xix35245 inv02 $PINS Y=nx35246 A=nx36832
Xix35247 inv02 $PINS Y=nx35248 A=nx36832
Xix35249 inv02 $PINS Y=nx35250 A=nx36832
Xix35251 inv02 $PINS Y=nx35252 A=nx36832
Xix35253 inv02 $PINS Y=nx35254 A=nx36832
Xix35255 inv02 $PINS Y=nx35256 A=nx36832
Xix35257 inv02 $PINS Y=nx35258 A=nx36834
Xix35259 inv02 $PINS Y=nx35260 A=nx36834
Xix35261 inv02 $PINS Y=nx35262 A=nx36834
Xix35263 inv02 $PINS Y=nx35264 A=nx36834
Xix35265 inv02 $PINS Y=nx35266 A=nx36834
Xix35267 inv02 $PINS Y=nx35268 A=nx36834
Xix35269 inv02 $PINS Y=nx35270 A=nx36834
Xix35271 inv02 $PINS Y=nx35272 A=nx36836
Xix35273 inv02 $PINS Y=nx35274 A=nx36836
Xix35275 inv02 $PINS Y=nx35276 A=nx36836
Xix35277 inv02 $PINS Y=nx35278 A=nx36836
Xix35279 inv02 $PINS Y=nx35280 A=nx36836
Xix35281 inv02 $PINS Y=nx35282 A=nx36836
Xix35283 inv02 $PINS Y=nx35284 A=nx36836
Xix35285 inv02 $PINS Y=nx35286 A=nx36838
Xix35287 inv02 $PINS Y=nx35288 A=nx36838
Xix35291 inv02 $PINS Y=nx35292 A=nx36840
Xix35293 inv02 $PINS Y=nx35294 A=nx36840
Xix35295 inv02 $PINS Y=nx35296 A=nx36840
Xix35297 inv02 $PINS Y=nx35298 A=nx36840
Xix35299 inv02 $PINS Y=nx35300 A=nx36840
Xix35301 inv02 $PINS Y=nx35302 A=nx36840
Xix35303 inv02 $PINS Y=nx35304 A=nx36840
Xix35305 inv02 $PINS Y=nx35306 A=nx36842
Xix35307 inv02 $PINS Y=nx35308 A=nx36842
Xix35309 inv02 $PINS Y=nx35310 A=nx36842
Xix35311 inv02 $PINS Y=nx35312 A=nx36842
Xix35313 inv02 $PINS Y=nx35314 A=nx36842
Xix35315 inv02 $PINS Y=nx35316 A=nx36842
Xix35317 inv02 $PINS Y=nx35318 A=nx36842
Xix35319 inv02 $PINS Y=nx35320 A=nx36844
Xix35321 inv02 $PINS Y=nx35322 A=nx36844
Xix35323 inv02 $PINS Y=nx35324 A=nx36844
Xix35325 inv02 $PINS Y=nx35326 A=nx36844
Xix35327 inv02 $PINS Y=nx35328 A=nx36844
Xix35329 inv02 $PINS Y=nx35330 A=nx36844
Xix35331 inv02 $PINS Y=nx35332 A=nx36844
Xix35333 inv02 $PINS Y=nx35334 A=nx36846
Xix35335 inv02 $PINS Y=nx35336 A=nx36846
Xix35337 inv02 $PINS Y=nx35338 A=nx36846
Xix35339 inv02 $PINS Y=nx35340 A=nx36846
Xix35341 inv02 $PINS Y=nx35342 A=nx36846
Xix35343 inv02 $PINS Y=nx35344 A=nx36846
Xix35345 inv02 $PINS Y=nx35346 A=nx36846
Xix35347 inv02 $PINS Y=nx35348 A=nx36848
Xix35349 inv02 $PINS Y=nx35350 A=nx36848
Xix35351 inv02 $PINS Y=nx35352 A=nx36848
Xix35353 inv02 $PINS Y=nx35354 A=nx36848
Xix35355 inv02 $PINS Y=nx35356 A=nx36848
Xix35357 inv02 $PINS Y=nx35358 A=nx36848
Xix35359 inv02 $PINS Y=nx35360 A=nx36848
Xix35361 inv02 $PINS Y=nx35362 A=nx36850
Xix35363 inv02 $PINS Y=nx35364 A=nx36850
Xix35367 inv02 $PINS Y=nx35368 A=nx36852
Xix35369 inv02 $PINS Y=nx35370 A=nx36852
Xix35371 inv02 $PINS Y=nx35372 A=nx36852
Xix35373 inv02 $PINS Y=nx35374 A=nx36852
Xix35375 inv02 $PINS Y=nx35376 A=nx36852
Xix35377 inv02 $PINS Y=nx35378 A=nx36852
Xix35379 inv02 $PINS Y=nx35380 A=nx36852
Xix35381 inv02 $PINS Y=nx35382 A=nx36854
Xix35383 inv02 $PINS Y=nx35384 A=nx36854
Xix35385 inv02 $PINS Y=nx35386 A=nx36854
Xix35387 inv02 $PINS Y=nx35388 A=nx36854
Xix35389 inv02 $PINS Y=nx35390 A=nx36854
Xix35391 inv02 $PINS Y=nx35392 A=nx36854
Xix35393 inv02 $PINS Y=nx35394 A=nx36854
Xix35395 inv02 $PINS Y=nx35396 A=nx36856
Xix35397 inv02 $PINS Y=nx35398 A=nx36856
Xix35399 inv02 $PINS Y=nx35400 A=nx36856
Xix35401 inv02 $PINS Y=nx35402 A=nx36856
Xix35403 inv02 $PINS Y=nx35404 A=nx36856
Xix35405 inv02 $PINS Y=nx35406 A=nx36856
Xix35407 inv02 $PINS Y=nx35408 A=nx36856
Xix35409 inv02 $PINS Y=nx35410 A=nx36858
Xix35411 inv02 $PINS Y=nx35412 A=nx36858
Xix35413 inv02 $PINS Y=nx35414 A=nx36858
Xix35415 inv02 $PINS Y=nx35416 A=nx36858
Xix35417 inv02 $PINS Y=nx35418 A=nx36858
Xix35419 inv02 $PINS Y=nx35420 A=nx36858
Xix35421 inv02 $PINS Y=nx35422 A=nx36858
Xix35423 inv02 $PINS Y=nx35424 A=nx36860
Xix35425 inv02 $PINS Y=nx35426 A=nx36860
Xix35427 inv02 $PINS Y=nx35428 A=nx36860
Xix35429 inv02 $PINS Y=nx35430 A=nx36860
Xix35431 inv02 $PINS Y=nx35432 A=nx36860
Xix35433 inv02 $PINS Y=nx35434 A=nx36860
Xix35435 inv02 $PINS Y=nx35436 A=nx36860
Xix35437 inv02 $PINS Y=nx35438 A=nx36862
Xix35439 inv02 $PINS Y=nx35440 A=nx36862
Xix35443 inv02 $PINS Y=nx35444 A=nx36864
Xix35445 inv02 $PINS Y=nx35446 A=nx36864
Xix35447 inv02 $PINS Y=nx35448 A=nx36864
Xix35449 inv02 $PINS Y=nx35450 A=nx36864
Xix35451 inv02 $PINS Y=nx35452 A=nx36864
Xix35453 inv02 $PINS Y=nx35454 A=nx36864
Xix35455 inv02 $PINS Y=nx35456 A=nx36864
Xix35457 inv02 $PINS Y=nx35458 A=nx36866
Xix35459 inv02 $PINS Y=nx35460 A=nx36866
Xix35461 inv02 $PINS Y=nx35462 A=nx36866
Xix35463 inv02 $PINS Y=nx35464 A=nx36866
Xix35465 inv02 $PINS Y=nx35466 A=nx36866
Xix35467 inv02 $PINS Y=nx35468 A=nx36866
Xix35469 inv02 $PINS Y=nx35470 A=nx36866
Xix35471 inv02 $PINS Y=nx35472 A=nx36868
Xix35473 inv02 $PINS Y=nx35474 A=nx36868
Xix35475 inv02 $PINS Y=nx35476 A=nx36868
Xix35477 inv02 $PINS Y=nx35478 A=nx36868
Xix35479 inv02 $PINS Y=nx35480 A=nx36868
Xix35481 inv02 $PINS Y=nx35482 A=nx36868
Xix35483 inv02 $PINS Y=nx35484 A=nx36868
Xix35485 inv02 $PINS Y=nx35486 A=nx36870
Xix35487 inv02 $PINS Y=nx35488 A=nx36870
Xix35489 inv02 $PINS Y=nx35490 A=nx36870
Xix35491 inv02 $PINS Y=nx35492 A=nx36870
Xix35493 inv02 $PINS Y=nx35494 A=nx36870
Xix35495 inv02 $PINS Y=nx35496 A=nx36870
Xix35497 inv02 $PINS Y=nx35498 A=nx36870
Xix35499 inv02 $PINS Y=nx35500 A=nx36872
Xix35501 inv02 $PINS Y=nx35502 A=nx36872
Xix35503 inv02 $PINS Y=nx35504 A=nx36872
Xix35505 inv02 $PINS Y=nx35506 A=nx36872
Xix35507 inv02 $PINS Y=nx35508 A=nx36872
Xix35509 inv02 $PINS Y=nx35510 A=nx36872
Xix35511 inv02 $PINS Y=nx35512 A=nx36872
Xix35513 inv02 $PINS Y=nx35514 A=nx36874
Xix35515 inv02 $PINS Y=nx35516 A=nx36874
Xix35519 inv02 $PINS Y=nx35520 A=nx36876
Xix35521 inv02 $PINS Y=nx35522 A=nx36876
Xix35523 inv02 $PINS Y=nx35524 A=nx36876
Xix35525 inv02 $PINS Y=nx35526 A=nx36876
Xix35527 inv02 $PINS Y=nx35528 A=nx36876
Xix35529 inv02 $PINS Y=nx35530 A=nx36876
Xix35531 inv02 $PINS Y=nx35532 A=nx36876
Xix35533 inv02 $PINS Y=nx35534 A=nx36878
Xix35535 inv02 $PINS Y=nx35536 A=nx36878
Xix35537 inv02 $PINS Y=nx35538 A=nx36878
Xix35539 inv02 $PINS Y=nx35540 A=nx36878
Xix35541 inv02 $PINS Y=nx35542 A=nx36878
Xix35543 inv02 $PINS Y=nx35544 A=nx36878
Xix35545 inv02 $PINS Y=nx35546 A=nx36878
Xix35547 inv02 $PINS Y=nx35548 A=nx36880
Xix35549 inv02 $PINS Y=nx35550 A=nx36880
Xix35551 inv02 $PINS Y=nx35552 A=nx36880
Xix35553 inv02 $PINS Y=nx35554 A=nx36880
Xix35555 inv02 $PINS Y=nx35556 A=nx36880
Xix35557 inv02 $PINS Y=nx35558 A=nx36880
Xix35559 inv02 $PINS Y=nx35560 A=nx36880
Xix35561 inv02 $PINS Y=nx35562 A=nx36882
Xix35563 inv02 $PINS Y=nx35564 A=nx36882
Xix35565 inv02 $PINS Y=nx35566 A=nx36882
Xix35567 inv02 $PINS Y=nx35568 A=nx36882
Xix35569 inv02 $PINS Y=nx35570 A=nx36882
Xix35571 inv02 $PINS Y=nx35572 A=nx36882
Xix35573 inv02 $PINS Y=nx35574 A=nx36882
Xix35575 inv02 $PINS Y=nx35576 A=nx36884
Xix35577 inv02 $PINS Y=nx35578 A=nx36884
Xix35579 inv02 $PINS Y=nx35580 A=nx36884
Xix35581 inv02 $PINS Y=nx35582 A=nx36884
Xix35583 inv02 $PINS Y=nx35584 A=nx36884
Xix35585 inv02 $PINS Y=nx35586 A=nx36884
Xix35587 inv02 $PINS Y=nx35588 A=nx36884
Xix35589 inv02 $PINS Y=nx35590 A=nx36886
Xix35591 inv02 $PINS Y=nx35592 A=nx36886
Xix35595 inv02 $PINS Y=nx35596 A=nx36888
Xix35597 inv02 $PINS Y=nx35598 A=nx36888
Xix35599 inv02 $PINS Y=nx35600 A=nx36888
Xix35601 inv02 $PINS Y=nx35602 A=nx36888
Xix35603 inv02 $PINS Y=nx35604 A=nx36888
Xix35605 inv02 $PINS Y=nx35606 A=nx36888
Xix35607 inv02 $PINS Y=nx35608 A=nx36888
Xix35609 inv02 $PINS Y=nx35610 A=nx36890
Xix35611 inv02 $PINS Y=nx35612 A=nx36890
Xix35613 inv02 $PINS Y=nx35614 A=nx36890
Xix35615 inv02 $PINS Y=nx35616 A=nx36890
Xix35617 inv02 $PINS Y=nx35618 A=nx36890
Xix35619 inv02 $PINS Y=nx35620 A=nx36890
Xix35621 inv02 $PINS Y=nx35622 A=nx36890
Xix35623 inv02 $PINS Y=nx35624 A=nx36892
Xix35625 inv02 $PINS Y=nx35626 A=nx36892
Xix35627 inv02 $PINS Y=nx35628 A=nx36892
Xix35629 inv02 $PINS Y=nx35630 A=nx36892
Xix35631 inv02 $PINS Y=nx35632 A=nx36892
Xix35633 inv02 $PINS Y=nx35634 A=nx36892
Xix35635 inv02 $PINS Y=nx35636 A=nx36892
Xix35637 inv02 $PINS Y=nx35638 A=nx36894
Xix35639 inv02 $PINS Y=nx35640 A=nx36894
Xix35641 inv02 $PINS Y=nx35642 A=nx36894
Xix35643 inv02 $PINS Y=nx35644 A=nx36894
Xix35645 inv02 $PINS Y=nx35646 A=nx36894
Xix35647 inv02 $PINS Y=nx35648 A=nx36894
Xix35649 inv02 $PINS Y=nx35650 A=nx36894
Xix35651 inv02 $PINS Y=nx35652 A=nx36896
Xix35653 inv02 $PINS Y=nx35654 A=nx36896
Xix35655 inv02 $PINS Y=nx35656 A=nx36896
Xix35657 inv02 $PINS Y=nx35658 A=nx36896
Xix35659 inv02 $PINS Y=nx35660 A=nx36896
Xix35661 inv02 $PINS Y=nx35662 A=nx36896
Xix35663 inv02 $PINS Y=nx35664 A=nx36896
Xix35665 inv02 $PINS Y=nx35666 A=nx36898
Xix35667 inv02 $PINS Y=nx35668 A=nx36898
Xix35669 inv02 $PINS Y=nx35670 A=zero
Xix35671 inv02 $PINS Y=nx35672 A=zero
Xix35673 inv02 $PINS Y=nx35674 A=zero
Xix35675 inv02 $PINS Y=nx35676 A=zero
Xix35677 inv02 $PINS Y=nx35678 A=zero
Xix35679 inv02 $PINS Y=nx35680 A=zero
Xix35681 inv02 $PINS Y=nx35682 A=zero
Xix35683 inv02 $PINS Y=nx35684 A=zero
Xix35685 inv02 $PINS Y=nx35686 A=camera_module_algo_module_regs_rst
Xix35687 inv02 $PINS Y=nx35688 A=nx37416
Xix35689 inv02 $PINS Y=nx35690 A=nx37416
Xix35691 inv02 $PINS Y=nx35692 A=rst
Xix35693 inv02 $PINS Y=nx35694 A=rst
Xix35695 inv02 $PINS Y=nx35696 A=nx879
Xix35697 inv02 $PINS Y=nx35698 A=nx879
Xix35699 inv02 $PINS Y=nx35700 A=nx25432
Xix35701 inv02 $PINS Y=nx35702 A=nx37090
Xix35703 inv02 $PINS Y=nx35704 A=nx37090
Xix35707 inv02 $PINS Y=nx35708 A=nx37086
Xix35711 buf02 $PINS Y=nx35712 A=nx22766
Xix35713 buf02 $PINS Y=nx35714 A=nx22766
Xix35717 inv02 $PINS Y=nx35718 A=camera_module_cache_address_from_DMA_0
Xix35719 inv02 $PINS Y=nx35720 A=nx37412
Xix35781 inv02 $PINS Y=nx35782 A=nx436
Xix35783 inv02 $PINS Y=nx35784 A=nx436
Xix35785 inv02 $PINS Y=nx35786 A=nx37370
Xix35795 inv02 $PINS Y=nx35796 A=nx37074
Xix35803 inv02 $PINS Y=nx35804 A=nx686
Xix35805 inv02 $PINS Y=nx35806 A=nx686
Xix35807 inv02 $PINS Y=nx35808 A=nx1490
Xix35809 inv02 $PINS Y=nx35810 A=nx37404
Xix35811 inv02 $PINS Y=nx35812 A=nx37404
Xix35813 inv02 $PINS Y=nx35814 A=nx37404
Xix35815 inv02 $PINS Y=nx35816 A=nx37404
Xix35817 inv02 $PINS Y=nx35818 A=nx37404
Xix35819 inv02 $PINS Y=nx35820 A=nx37404
Xix35821 inv02 $PINS Y=nx35822 A=nx37404
Xix35823 inv02 $PINS Y=nx35824 A=nx37010
Xix35825 inv02 $PINS Y=nx35826 A=nx37010
Xix35827 inv02 $PINS Y=nx35828 A=nx37010
Xix35829 inv02 $PINS Y=nx35830 A=nx37010
Xix35831 inv02 $PINS Y=nx35832 A=nx37010
Xix35833 inv02 $PINS Y=nx35834 A=nx37010
Xix35835 inv02 $PINS Y=nx35836 A=nx37010
Xix35837 inv02 $PINS Y=nx35838 A=nx37012
Xix35839 inv02 $PINS Y=nx35840 A=nx37012
Xix35841 inv02 $PINS Y=nx35842 A=nx37012
Xix35843 inv02 $PINS Y=nx35844 A=nx37012
Xix35845 inv02 $PINS Y=nx35846 A=nx37012
Xix35847 inv02 $PINS Y=nx35848 A=nx1472
Xix35849 inv02 $PINS Y=nx35850 A=nx37402
Xix35851 inv02 $PINS Y=nx35852 A=nx37402
Xix35853 inv02 $PINS Y=nx35854 A=nx37402
Xix35855 inv02 $PINS Y=nx35856 A=nx37402
Xix35857 inv02 $PINS Y=nx35858 A=nx37402
Xix35859 inv02 $PINS Y=nx35860 A=nx37402
Xix35861 inv02 $PINS Y=nx35862 A=nx37402
Xix35863 inv02 $PINS Y=nx35864 A=nx37004
Xix35865 inv02 $PINS Y=nx35866 A=nx37004
Xix35867 inv02 $PINS Y=nx35868 A=nx37004
Xix35869 inv02 $PINS Y=nx35870 A=nx37004
Xix35871 inv02 $PINS Y=nx35872 A=nx37004
Xix35873 inv02 $PINS Y=nx35874 A=nx37004
Xix35875 inv02 $PINS Y=nx35876 A=nx37004
Xix35877 inv02 $PINS Y=nx35878 A=nx37006
Xix35879 inv02 $PINS Y=nx35880 A=nx37006
Xix35881 inv02 $PINS Y=nx35882 A=nx37006
Xix35883 inv02 $PINS Y=nx35884 A=nx37006
Xix35885 inv02 $PINS Y=nx35886 A=nx37006
Xix35887 inv02 $PINS Y=nx35888 A=nx1452
Xix35889 inv02 $PINS Y=nx35890 A=nx37400
Xix35891 inv02 $PINS Y=nx35892 A=nx37400
Xix35893 inv02 $PINS Y=nx35894 A=nx37400
Xix35895 inv02 $PINS Y=nx35896 A=nx37400
Xix35897 inv02 $PINS Y=nx35898 A=nx37400
Xix35899 inv02 $PINS Y=nx35900 A=nx37400
Xix35901 inv02 $PINS Y=nx35902 A=nx37400
Xix35903 inv02 $PINS Y=nx35904 A=nx36998
Xix35905 inv02 $PINS Y=nx35906 A=nx36998
Xix35907 inv02 $PINS Y=nx35908 A=nx36998
Xix35909 inv02 $PINS Y=nx35910 A=nx36998
Xix35911 inv02 $PINS Y=nx35912 A=nx36998
Xix35913 inv02 $PINS Y=nx35914 A=nx36998
Xix35915 inv02 $PINS Y=nx35916 A=nx36998
Xix35917 inv02 $PINS Y=nx35918 A=nx37000
Xix35919 inv02 $PINS Y=nx35920 A=nx37000
Xix35921 inv02 $PINS Y=nx35922 A=nx37000
Xix35923 inv02 $PINS Y=nx35924 A=nx37000
Xix35925 inv02 $PINS Y=nx35926 A=nx37000
Xix35927 inv02 $PINS Y=nx35928 A=nx1434
Xix35929 inv02 $PINS Y=nx35930 A=nx37398
Xix35931 inv02 $PINS Y=nx35932 A=nx37398
Xix35933 inv02 $PINS Y=nx35934 A=nx37398
Xix35935 inv02 $PINS Y=nx35936 A=nx37398
Xix35937 inv02 $PINS Y=nx35938 A=nx37398
Xix35939 inv02 $PINS Y=nx35940 A=nx37398
Xix35941 inv02 $PINS Y=nx35942 A=nx37398
Xix35943 inv02 $PINS Y=nx35944 A=nx36992
Xix35945 inv02 $PINS Y=nx35946 A=nx36992
Xix35947 inv02 $PINS Y=nx35948 A=nx36992
Xix35949 inv02 $PINS Y=nx35950 A=nx36992
Xix35951 inv02 $PINS Y=nx35952 A=nx36992
Xix35953 inv02 $PINS Y=nx35954 A=nx36992
Xix35955 inv02 $PINS Y=nx35956 A=nx36992
Xix35957 inv02 $PINS Y=nx35958 A=nx36994
Xix35959 inv02 $PINS Y=nx35960 A=nx36994
Xix35961 inv02 $PINS Y=nx35962 A=nx36994
Xix35963 inv02 $PINS Y=nx35964 A=nx36994
Xix35965 inv02 $PINS Y=nx35966 A=nx36994
Xix35967 inv02 $PINS Y=nx35968 A=nx1410
Xix35969 inv02 $PINS Y=nx35970 A=nx37396
Xix35971 inv02 $PINS Y=nx35972 A=nx37396
Xix35973 inv02 $PINS Y=nx35974 A=nx37396
Xix35975 inv02 $PINS Y=nx35976 A=nx37396
Xix35977 inv02 $PINS Y=nx35978 A=nx37396
Xix35979 inv02 $PINS Y=nx35980 A=nx37396
Xix35981 inv02 $PINS Y=nx35982 A=nx37396
Xix35983 inv02 $PINS Y=nx35984 A=nx36986
Xix35985 inv02 $PINS Y=nx35986 A=nx36986
Xix35987 inv02 $PINS Y=nx35988 A=nx36986
Xix35989 inv02 $PINS Y=nx35990 A=nx36986
Xix35991 inv02 $PINS Y=nx35992 A=nx36986
Xix35993 inv02 $PINS Y=nx35994 A=nx36986
Xix35995 inv02 $PINS Y=nx35996 A=nx36986
Xix35997 inv02 $PINS Y=nx35998 A=nx36988
Xix35999 inv02 $PINS Y=nx36000 A=nx36988
Xix36001 inv02 $PINS Y=nx36002 A=nx36988
Xix36003 inv02 $PINS Y=nx36004 A=nx36988
Xix36005 inv02 $PINS Y=nx36006 A=nx36988
Xix36007 inv02 $PINS Y=nx36008 A=nx1392
Xix36009 inv02 $PINS Y=nx36010 A=nx37394
Xix36011 inv02 $PINS Y=nx36012 A=nx37394
Xix36013 inv02 $PINS Y=nx36014 A=nx37394
Xix36015 inv02 $PINS Y=nx36016 A=nx37394
Xix36017 inv02 $PINS Y=nx36018 A=nx37394
Xix36019 inv02 $PINS Y=nx36020 A=nx37394
Xix36021 inv02 $PINS Y=nx36022 A=nx37394
Xix36023 inv02 $PINS Y=nx36024 A=nx36980
Xix36025 inv02 $PINS Y=nx36026 A=nx36980
Xix36027 inv02 $PINS Y=nx36028 A=nx36980
Xix36029 inv02 $PINS Y=nx36030 A=nx36980
Xix36031 inv02 $PINS Y=nx36032 A=nx36980
Xix36033 inv02 $PINS Y=nx36034 A=nx36980
Xix36035 inv02 $PINS Y=nx36036 A=nx36980
Xix36037 inv02 $PINS Y=nx36038 A=nx36982
Xix36039 inv02 $PINS Y=nx36040 A=nx36982
Xix36041 inv02 $PINS Y=nx36042 A=nx36982
Xix36043 inv02 $PINS Y=nx36044 A=nx36982
Xix36045 inv02 $PINS Y=nx36046 A=nx36982
Xix36047 inv02 $PINS Y=nx36048 A=nx1354
Xix36049 inv02 $PINS Y=nx36050 A=nx37390
Xix36051 inv02 $PINS Y=nx36052 A=nx37390
Xix36053 inv02 $PINS Y=nx36054 A=nx37390
Xix36055 inv02 $PINS Y=nx36056 A=nx37390
Xix36057 inv02 $PINS Y=nx36058 A=nx37390
Xix36059 inv02 $PINS Y=nx36060 A=nx37390
Xix36061 inv02 $PINS Y=nx36062 A=nx37390
Xix36063 inv02 $PINS Y=nx36064 A=nx36968
Xix36065 inv02 $PINS Y=nx36066 A=nx36968
Xix36067 inv02 $PINS Y=nx36068 A=nx36968
Xix36069 inv02 $PINS Y=nx36070 A=nx36968
Xix36071 inv02 $PINS Y=nx36072 A=nx36968
Xix36073 inv02 $PINS Y=nx36074 A=nx36968
Xix36075 inv02 $PINS Y=nx36076 A=nx36968
Xix36077 inv02 $PINS Y=nx36078 A=nx36970
Xix36079 inv02 $PINS Y=nx36080 A=nx36970
Xix36081 inv02 $PINS Y=nx36082 A=nx36970
Xix36083 inv02 $PINS Y=nx36084 A=nx36970
Xix36085 inv02 $PINS Y=nx36086 A=nx36970
Xix36087 inv02 $PINS Y=nx36088 A=nx1372
Xix36089 inv02 $PINS Y=nx36090 A=nx37392
Xix36091 inv02 $PINS Y=nx36092 A=nx37392
Xix36093 inv02 $PINS Y=nx36094 A=nx37392
Xix36095 inv02 $PINS Y=nx36096 A=nx37392
Xix36097 inv02 $PINS Y=nx36098 A=nx37392
Xix36099 inv02 $PINS Y=nx36100 A=nx37392
Xix36101 inv02 $PINS Y=nx36102 A=nx37392
Xix36103 inv02 $PINS Y=nx36104 A=nx36974
Xix36105 inv02 $PINS Y=nx36106 A=nx36974
Xix36107 inv02 $PINS Y=nx36108 A=nx36974
Xix36109 inv02 $PINS Y=nx36110 A=nx36974
Xix36111 inv02 $PINS Y=nx36112 A=nx36974
Xix36113 inv02 $PINS Y=nx36114 A=nx36974
Xix36115 inv02 $PINS Y=nx36116 A=nx36974
Xix36117 inv02 $PINS Y=nx36118 A=nx36976
Xix36119 inv02 $PINS Y=nx36120 A=nx36976
Xix36121 inv02 $PINS Y=nx36122 A=nx36976
Xix36123 inv02 $PINS Y=nx36124 A=nx36976
Xix36125 inv02 $PINS Y=nx36126 A=nx36976
Xix36127 inv02 $PINS Y=nx36128 A=nx1326
Xix36129 inv02 $PINS Y=nx36130 A=nx37388
Xix36131 inv02 $PINS Y=nx36132 A=nx37388
Xix36133 inv02 $PINS Y=nx36134 A=nx37388
Xix36135 inv02 $PINS Y=nx36136 A=nx37388
Xix36137 inv02 $PINS Y=nx36138 A=nx37388
Xix36139 inv02 $PINS Y=nx36140 A=nx37388
Xix36141 inv02 $PINS Y=nx36142 A=nx37388
Xix36143 inv02 $PINS Y=nx36144 A=nx36962
Xix36145 inv02 $PINS Y=nx36146 A=nx36962
Xix36147 inv02 $PINS Y=nx36148 A=nx36962
Xix36149 inv02 $PINS Y=nx36150 A=nx36962
Xix36151 inv02 $PINS Y=nx36152 A=nx36962
Xix36153 inv02 $PINS Y=nx36154 A=nx36962
Xix36155 inv02 $PINS Y=nx36156 A=nx36962
Xix36157 inv02 $PINS Y=nx36158 A=nx36964
Xix36159 inv02 $PINS Y=nx36160 A=nx36964
Xix36161 inv02 $PINS Y=nx36162 A=nx36964
Xix36163 inv02 $PINS Y=nx36164 A=nx36964
Xix36165 inv02 $PINS Y=nx36166 A=nx36964
Xix36167 inv02 $PINS Y=nx36168 A=nx1308
Xix36169 inv02 $PINS Y=nx36170 A=nx37386
Xix36171 inv02 $PINS Y=nx36172 A=nx37386
Xix36173 inv02 $PINS Y=nx36174 A=nx37386
Xix36175 inv02 $PINS Y=nx36176 A=nx37386
Xix36177 inv02 $PINS Y=nx36178 A=nx37386
Xix36179 inv02 $PINS Y=nx36180 A=nx37386
Xix36181 inv02 $PINS Y=nx36182 A=nx37386
Xix36183 inv02 $PINS Y=nx36184 A=nx36956
Xix36185 inv02 $PINS Y=nx36186 A=nx36956
Xix36187 inv02 $PINS Y=nx36188 A=nx36956
Xix36189 inv02 $PINS Y=nx36190 A=nx36956
Xix36191 inv02 $PINS Y=nx36192 A=nx36956
Xix36193 inv02 $PINS Y=nx36194 A=nx36956
Xix36195 inv02 $PINS Y=nx36196 A=nx36956
Xix36197 inv02 $PINS Y=nx36198 A=nx36958
Xix36199 inv02 $PINS Y=nx36200 A=nx36958
Xix36201 inv02 $PINS Y=nx36202 A=nx36958
Xix36203 inv02 $PINS Y=nx36204 A=nx36958
Xix36205 inv02 $PINS Y=nx36206 A=nx36958
Xix36207 inv02 $PINS Y=nx36208 A=nx1270
Xix36209 inv02 $PINS Y=nx36210 A=nx37382
Xix36211 inv02 $PINS Y=nx36212 A=nx37382
Xix36213 inv02 $PINS Y=nx36214 A=nx37382
Xix36215 inv02 $PINS Y=nx36216 A=nx37382
Xix36217 inv02 $PINS Y=nx36218 A=nx37382
Xix36219 inv02 $PINS Y=nx36220 A=nx37382
Xix36221 inv02 $PINS Y=nx36222 A=nx37382
Xix36223 inv02 $PINS Y=nx36224 A=nx36944
Xix36225 inv02 $PINS Y=nx36226 A=nx36944
Xix36227 inv02 $PINS Y=nx36228 A=nx36944
Xix36229 inv02 $PINS Y=nx36230 A=nx36944
Xix36231 inv02 $PINS Y=nx36232 A=nx36944
Xix36233 inv02 $PINS Y=nx36234 A=nx36944
Xix36235 inv02 $PINS Y=nx36236 A=nx36944
Xix36237 inv02 $PINS Y=nx36238 A=nx36946
Xix36239 inv02 $PINS Y=nx36240 A=nx36946
Xix36241 inv02 $PINS Y=nx36242 A=nx36946
Xix36243 inv02 $PINS Y=nx36244 A=nx36946
Xix36245 inv02 $PINS Y=nx36246 A=nx36946
Xix36247 inv02 $PINS Y=nx36248 A=nx1288
Xix36249 inv02 $PINS Y=nx36250 A=nx37384
Xix36251 inv02 $PINS Y=nx36252 A=nx37384
Xix36253 inv02 $PINS Y=nx36254 A=nx37384
Xix36255 inv02 $PINS Y=nx36256 A=nx37384
Xix36257 inv02 $PINS Y=nx36258 A=nx37384
Xix36259 inv02 $PINS Y=nx36260 A=nx37384
Xix36261 inv02 $PINS Y=nx36262 A=nx37384
Xix36263 inv02 $PINS Y=nx36264 A=nx36950
Xix36265 inv02 $PINS Y=nx36266 A=nx36950
Xix36267 inv02 $PINS Y=nx36268 A=nx36950
Xix36269 inv02 $PINS Y=nx36270 A=nx36950
Xix36271 inv02 $PINS Y=nx36272 A=nx36950
Xix36273 inv02 $PINS Y=nx36274 A=nx36950
Xix36275 inv02 $PINS Y=nx36276 A=nx36950
Xix36277 inv02 $PINS Y=nx36278 A=nx36952
Xix36279 inv02 $PINS Y=nx36280 A=nx36952
Xix36281 inv02 $PINS Y=nx36282 A=nx36952
Xix36283 inv02 $PINS Y=nx36284 A=nx36952
Xix36285 inv02 $PINS Y=nx36286 A=nx36952
Xix36287 inv02 $PINS Y=nx36288 A=nx37380
Xix36289 inv02 $PINS Y=nx36290 A=nx37380
Xix36291 inv02 $PINS Y=nx36292 A=nx37380
Xix36293 inv02 $PINS Y=nx36294 A=nx37380
Xix36295 inv02 $PINS Y=nx36296 A=nx37380
Xix36297 inv02 $PINS Y=nx36298 A=nx37380
Xix36299 inv02 $PINS Y=nx36300 A=nx37380
Xix36301 inv02 $PINS Y=nx36302 A=nx36938
Xix36303 inv02 $PINS Y=nx36304 A=nx36938
Xix36305 inv02 $PINS Y=nx36306 A=nx36938
Xix36307 inv02 $PINS Y=nx36308 A=nx36938
Xix36309 inv02 $PINS Y=nx36310 A=nx36938
Xix36311 inv02 $PINS Y=nx36312 A=nx36938
Xix36313 inv02 $PINS Y=nx36314 A=nx36938
Xix36315 inv02 $PINS Y=nx36316 A=nx36940
Xix36317 inv02 $PINS Y=nx36318 A=nx36940
Xix36319 inv02 $PINS Y=nx36320 A=nx36940
Xix36321 inv02 $PINS Y=nx36322 A=nx36940
Xix36323 inv02 $PINS Y=nx36324 A=nx36940
Xix36325 inv02 $PINS Y=nx36326 A=nx36940
Xix36327 inv02 $PINS Y=nx36328 A=nx37378
Xix36329 inv02 $PINS Y=nx36330 A=nx37378
Xix36331 inv02 $PINS Y=nx36332 A=nx37378
Xix36333 inv02 $PINS Y=nx36334 A=nx37378
Xix36335 inv02 $PINS Y=nx36336 A=nx37378
Xix36337 inv02 $PINS Y=nx36338 A=nx37378
Xix36339 inv02 $PINS Y=nx36340 A=nx37378
Xix36341 inv02 $PINS Y=nx36342 A=nx36932
Xix36343 inv02 $PINS Y=nx36344 A=nx36932
Xix36345 inv02 $PINS Y=nx36346 A=nx36932
Xix36347 inv02 $PINS Y=nx36348 A=nx36932
Xix36349 inv02 $PINS Y=nx36350 A=nx36932
Xix36351 inv02 $PINS Y=nx36352 A=nx36932
Xix36353 inv02 $PINS Y=nx36354 A=nx36932
Xix36355 inv02 $PINS Y=nx36356 A=nx36934
Xix36357 inv02 $PINS Y=nx36358 A=nx36934
Xix36359 inv02 $PINS Y=nx36360 A=nx36934
Xix36361 inv02 $PINS Y=nx36362 A=nx36934
Xix36363 inv02 $PINS Y=nx36364 A=nx36934
Xix36365 inv02 $PINS Y=nx36366 A=nx36934
Xix36367 inv02 $PINS Y=nx36368 A=nx37376
Xix36369 inv02 $PINS Y=nx36370 A=nx37376
Xix36371 inv02 $PINS Y=nx36372 A=nx37376
Xix36373 inv02 $PINS Y=nx36374 A=nx37376
Xix36375 inv02 $PINS Y=nx36376 A=nx37376
Xix36377 inv02 $PINS Y=nx36378 A=nx37376
Xix36379 inv02 $PINS Y=nx36380 A=nx37376
Xix36381 inv02 $PINS Y=nx36382 A=nx36926
Xix36383 inv02 $PINS Y=nx36384 A=nx36926
Xix36385 inv02 $PINS Y=nx36386 A=nx36926
Xix36387 inv02 $PINS Y=nx36388 A=nx36926
Xix36389 inv02 $PINS Y=nx36390 A=nx36926
Xix36391 inv02 $PINS Y=nx36392 A=nx36926
Xix36393 inv02 $PINS Y=nx36394 A=nx36926
Xix36395 inv02 $PINS Y=nx36396 A=nx36928
Xix36397 inv02 $PINS Y=nx36398 A=nx36928
Xix36399 inv02 $PINS Y=nx36400 A=nx36928
Xix36401 inv02 $PINS Y=nx36402 A=nx36928
Xix36403 inv02 $PINS Y=nx36404 A=nx36928
Xix36405 inv02 $PINS Y=nx36406 A=nx36928
Xix36407 inv02 $PINS Y=nx36408 A=nx37374
Xix36409 inv02 $PINS Y=nx36410 A=nx37374
Xix36411 inv02 $PINS Y=nx36412 A=nx37374
Xix36413 inv02 $PINS Y=nx36414 A=nx37374
Xix36415 inv02 $PINS Y=nx36416 A=nx37374
Xix36417 inv02 $PINS Y=nx36418 A=nx37374
Xix36419 inv02 $PINS Y=nx36420 A=nx37374
Xix36421 inv02 $PINS Y=nx36422 A=nx36918
Xix36423 inv02 $PINS Y=nx36424 A=nx36918
Xix36425 inv02 $PINS Y=nx36426 A=nx36918
Xix36427 inv02 $PINS Y=nx36428 A=nx36918
Xix36429 inv02 $PINS Y=nx36430 A=nx36918
Xix36431 inv02 $PINS Y=nx36432 A=nx36918
Xix36433 inv02 $PINS Y=nx36434 A=nx36918
Xix36435 inv02 $PINS Y=nx36436 A=nx36920
Xix36437 inv02 $PINS Y=nx36438 A=nx36920
Xix36439 inv02 $PINS Y=nx36440 A=nx36920
Xix36441 inv02 $PINS Y=nx36442 A=nx36920
Xix36443 inv02 $PINS Y=nx36444 A=nx36920
Xix36445 inv02 $PINS Y=nx36446 A=nx36920
Xix36447 inv02 $PINS Y=nx36448 A=nx5650
Xix36449 inv02 $PINS Y=nx36450 A=nx5650
Xix36451 inv02 $PINS Y=nx36452 A=nx5358
Xix36453 inv02 $PINS Y=nx36454 A=nx5358
Xix36455 inv02 $PINS Y=nx36456 A=nx5064
Xix36457 inv02 $PINS Y=nx36458 A=nx5064
Xix36459 inv02 $PINS Y=nx36460 A=nx4772
Xix36461 inv02 $PINS Y=nx36462 A=nx4772
Xix36463 inv02 $PINS Y=nx36464 A=nx4474
Xix36465 inv02 $PINS Y=nx36466 A=nx4474
Xix36467 inv02 $PINS Y=nx36468 A=nx4182
Xix36469 inv02 $PINS Y=nx36470 A=nx4182
Xix36471 inv02 $PINS Y=nx36472 A=nx3888
Xix36473 inv02 $PINS Y=nx36474 A=nx3888
Xix36475 inv02 $PINS Y=nx36476 A=nx3596
Xix36477 inv02 $PINS Y=nx36478 A=nx3596
Xix36479 inv02 $PINS Y=nx36480 A=nx3294
Xix36481 inv02 $PINS Y=nx36482 A=nx3294
Xix36483 inv02 $PINS Y=nx36484 A=nx3002
Xix36485 inv02 $PINS Y=nx36486 A=nx3002
Xix36487 inv02 $PINS Y=nx36488 A=nx2708
Xix36489 inv02 $PINS Y=nx36490 A=nx2708
Xix36491 inv02 $PINS Y=nx36492 A=nx2416
Xix36493 inv02 $PINS Y=nx36494 A=nx2416
Xix36495 buf02 $PINS Y=nx36496 A=nx24463
Xix36497 buf02 $PINS Y=nx36498 A=nx24463
Xix36505 inv02 $PINS Y=nx36506 A=nx36500
Xix36507 inv02 $PINS Y=nx36508 A=nx37280
Xix36509 buf02 $PINS Y=nx36510 A=nx24473
Xix36511 buf02 $PINS Y=nx36512 A=nx24473
Xix36513 buf02 $PINS Y=nx36514 A=nx24481
Xix36515 buf02 $PINS Y=nx36516 A=nx24481
Xix36517 buf02 $PINS Y=nx36518 A=nx24487
Xix36519 buf02 $PINS Y=nx36520 A=nx24487
Xix36521 buf02 $PINS Y=nx36522 A=nx24495
Xix36523 buf02 $PINS Y=nx36524 A=nx24495
Xix36525 buf02 $PINS Y=nx36526 A=nx24500
Xix36527 buf02 $PINS Y=nx36528 A=nx24500
Xix36529 buf02 $PINS Y=nx36530 A=nx24508
Xix36531 buf02 $PINS Y=nx36532 A=nx24508
Xix36533 buf02 $PINS Y=nx36534 A=nx24513
Xix36535 buf02 $PINS Y=nx36536 A=nx24513
Xix36537 buf02 $PINS Y=nx36538 A=nx24521
Xix36539 buf02 $PINS Y=nx36540 A=nx24521
Xix36541 buf02 $PINS Y=nx36542 A=nx24526
Xix36543 buf02 $PINS Y=nx36544 A=nx24526
Xix36545 buf02 $PINS Y=nx36546 A=nx24535
Xix36547 buf02 $PINS Y=nx36548 A=nx24535
Xix36549 buf02 $PINS Y=nx36550 A=nx24541
Xix36551 buf02 $PINS Y=nx36552 A=nx24541
Xix36553 buf02 $PINS Y=nx36554 A=nx24548
Xix36555 buf02 $PINS Y=nx36556 A=nx24548
Xix36557 buf02 $PINS Y=nx36558 A=nx24554
Xix36559 buf02 $PINS Y=nx36560 A=nx24554
Xix36561 buf02 $PINS Y=nx36562 A=nx24563
Xix36563 buf02 $PINS Y=nx36564 A=nx24563
Xix36565 buf02 $PINS Y=nx36566 A=nx24569
Xix36567 buf02 $PINS Y=nx36568 A=nx24569
Xix36569 buf02 $PINS Y=nx36570 A=nx24581
Xix36571 buf02 $PINS Y=nx36572 A=nx24581
Xix36579 inv02 $PINS Y=nx36580 A=nx36574
Xix36581 inv02 $PINS Y=nx36582 A=nx37286
Xix36583 buf02 $PINS Y=nx36584 A=nx24589
Xix36585 buf02 $PINS Y=nx36586 A=nx24589
Xix36587 buf02 $PINS Y=nx36588 A=nx24597
Xix36589 buf02 $PINS Y=nx36590 A=nx24597
Xix36591 buf02 $PINS Y=nx36592 A=nx24602
Xix36593 buf02 $PINS Y=nx36594 A=nx24602
Xix36595 buf02 $PINS Y=nx36596 A=nx24610
Xix36597 buf02 $PINS Y=nx36598 A=nx24610
Xix36599 buf02 $PINS Y=nx36600 A=nx24615
Xix36601 buf02 $PINS Y=nx36602 A=nx24615
Xix36603 buf02 $PINS Y=nx36604 A=nx24624
Xix36605 buf02 $PINS Y=nx36606 A=nx24624
Xix36607 buf02 $PINS Y=nx36608 A=nx24629
Xix36609 buf02 $PINS Y=nx36610 A=nx24629
Xix36611 buf02 $PINS Y=nx36612 A=nx24637
Xix36613 buf02 $PINS Y=nx36614 A=nx24637
Xix36615 buf02 $PINS Y=nx36616 A=nx24642
Xix36617 buf02 $PINS Y=nx36618 A=nx24642
Xix36619 buf02 $PINS Y=nx36620 A=nx24650
Xix36621 buf02 $PINS Y=nx36622 A=nx24650
Xix36623 buf02 $PINS Y=nx36624 A=nx24655
Xix36625 buf02 $PINS Y=nx36626 A=nx24655
Xix36627 buf02 $PINS Y=nx36628 A=nx24663
Xix36629 buf02 $PINS Y=nx36630 A=nx24663
Xix36631 buf02 $PINS Y=nx36632 A=nx24669
Xix36633 buf02 $PINS Y=nx36634 A=nx24669
Xix36635 buf02 $PINS Y=nx36636 A=nx24677
Xix36637 buf02 $PINS Y=nx36638 A=nx24677
Xix36639 buf02 $PINS Y=nx36640 A=nx24682
Xix36641 buf02 $PINS Y=nx36642 A=nx24682
Xix36643 buf02 $PINS Y=nx36644 A=nx24693
Xix36645 buf02 $PINS Y=nx36646 A=nx24693
Xix36653 inv02 $PINS Y=nx36654 A=nx36648
Xix36655 inv02 $PINS Y=nx36656 A=nx37292
Xix36657 buf02 $PINS Y=nx36658 A=nx24703
Xix36659 buf02 $PINS Y=nx36660 A=nx24703
Xix36661 buf02 $PINS Y=nx36662 A=nx24712
Xix36663 buf02 $PINS Y=nx36664 A=nx24712
Xix36665 buf02 $PINS Y=nx36666 A=nx24717
Xix36667 buf02 $PINS Y=nx36668 A=nx24717
Xix36669 buf02 $PINS Y=nx36670 A=nx24725
Xix36671 buf02 $PINS Y=nx36672 A=nx24725
Xix36673 buf02 $PINS Y=nx36674 A=nx24730
Xix36675 buf02 $PINS Y=nx36676 A=nx24730
Xix36677 buf02 $PINS Y=nx36678 A=nx24738
Xix36679 buf02 $PINS Y=nx36680 A=nx24738
Xix36681 buf02 $PINS Y=nx36682 A=nx24743
Xix36683 buf02 $PINS Y=nx36684 A=nx24743
Xix36685 buf02 $PINS Y=nx36686 A=nx24751
Xix36687 buf02 $PINS Y=nx36688 A=nx24751
Xix36689 buf02 $PINS Y=nx36690 A=nx24757
Xix36691 buf02 $PINS Y=nx36692 A=nx24757
Xix36693 buf02 $PINS Y=nx36694 A=nx24765
Xix36695 buf02 $PINS Y=nx36696 A=nx24765
Xix36697 buf02 $PINS Y=nx36698 A=nx24770
Xix36699 buf02 $PINS Y=nx36700 A=nx24770
Xix36701 buf02 $PINS Y=nx36702 A=nx24778
Xix36703 buf02 $PINS Y=nx36704 A=nx24778
Xix36705 buf02 $PINS Y=nx36706 A=nx24785
Xix36707 buf02 $PINS Y=nx36708 A=nx24785
Xix36709 buf02 $PINS Y=nx36710 A=nx24792
Xix36711 buf02 $PINS Y=nx36712 A=nx24792
Xix36713 buf02 $PINS Y=nx36714 A=nx24798
Xix36715 buf02 $PINS Y=nx36716 A=nx24798
Xix36717 buf02 $PINS Y=nx36718 A=nx24809
Xix36719 buf02 $PINS Y=nx36720 A=nx24809
Xix36727 inv02 $PINS Y=nx36728 A=nx37298
Xix36729 inv02 $PINS Y=nx36730 A=nx37298
Xix36731 buf02 $PINS Y=nx36732 A=nx24816
Xix36733 buf02 $PINS Y=nx36734 A=nx24816
Xix36735 buf02 $PINS Y=nx36736 A=nx24825
Xix36737 buf02 $PINS Y=nx36738 A=nx24825
Xix36739 buf02 $PINS Y=nx36740 A=nx24830
Xix36741 buf02 $PINS Y=nx36742 A=nx24830
Xix36743 buf02 $PINS Y=nx36744 A=nx24838
Xix36745 buf02 $PINS Y=nx36746 A=nx24838
Xix36747 buf02 $PINS Y=nx36748 A=nx24845
Xix36749 buf02 $PINS Y=nx36750 A=nx24845
Xix36751 buf02 $PINS Y=nx36752 A=nx24853
Xix36753 buf02 $PINS Y=nx36754 A=nx24853
Xix36755 buf02 $PINS Y=nx36756 A=nx24859
Xix36757 buf02 $PINS Y=nx36758 A=nx24859
Xix36759 buf02 $PINS Y=nx36760 A=nx24869
Xix36761 buf02 $PINS Y=nx36762 A=nx24869
Xix36763 buf02 $PINS Y=nx36764 A=nx24874
Xix36765 buf02 $PINS Y=nx36766 A=nx24874
Xix36767 buf02 $PINS Y=nx36768 A=nx24882
Xix36769 buf02 $PINS Y=nx36770 A=nx24882
Xix36771 buf02 $PINS Y=nx36772 A=nx24887
Xix36773 buf02 $PINS Y=nx36774 A=nx24887
Xix36775 buf02 $PINS Y=nx36776 A=nx24894
Xix36777 buf02 $PINS Y=nx36778 A=nx24894
Xix36779 buf02 $PINS Y=nx36780 A=nx24900
Xix36781 buf02 $PINS Y=nx36782 A=nx24900
Xix36783 buf02 $PINS Y=nx36784 A=nx24909
Xix36785 buf02 $PINS Y=nx36786 A=nx24909
Xix36787 buf02 $PINS Y=nx36788 A=nx24914
Xix36789 buf02 $PINS Y=nx36790 A=nx24914
Xix36791 buf02 $PINS Y=nx36792 A=nx24918
Xix36793 buf02 $PINS Y=nx36794 A=nx24918
Xix36803 inv02 $PINS Y=nx36804 A=nx1186
Xix36805 inv02 $PINS Y=nx36806 A=nx36922
Xix36807 inv02 $PINS Y=nx36808 A=nx36922
Xix36809 inv02 $PINS Y=nx36810 A=nx36922
Xix36811 inv02 $PINS Y=nx36812 A=nx36922
Xix36813 inv02 $PINS Y=nx36814 A=nx36922
Xix36815 inv02 $PINS Y=nx36816 A=nx6100
Xix36817 inv02 $PINS Y=nx36818 A=nx37014
Xix36819 inv02 $PINS Y=nx36820 A=nx37014
Xix36821 inv02 $PINS Y=nx36822 A=nx37014
Xix36823 inv02 $PINS Y=nx36824 A=nx37014
Xix36825 inv02 $PINS Y=nx36826 A=nx37014
Xix36827 inv02 $PINS Y=nx36828 A=nx8874
Xix36829 inv02 $PINS Y=nx36830 A=nx37016
Xix36831 inv02 $PINS Y=nx36832 A=nx37016
Xix36833 inv02 $PINS Y=nx36834 A=nx37016
Xix36835 inv02 $PINS Y=nx36836 A=nx37016
Xix36837 inv02 $PINS Y=nx36838 A=nx37016
Xix36839 inv02 $PINS Y=nx36840 A=nx11648
Xix36841 inv02 $PINS Y=nx36842 A=nx37018
Xix36843 inv02 $PINS Y=nx36844 A=nx37018
Xix36845 inv02 $PINS Y=nx36846 A=nx37018
Xix36847 inv02 $PINS Y=nx36848 A=nx37018
Xix36849 inv02 $PINS Y=nx36850 A=nx37018
Xix36851 inv02 $PINS Y=nx36852 A=nx14422
Xix36853 inv02 $PINS Y=nx36854 A=nx37020
Xix36855 inv02 $PINS Y=nx36856 A=nx37020
Xix36857 inv02 $PINS Y=nx36858 A=nx37020
Xix36859 inv02 $PINS Y=nx36860 A=nx37020
Xix36861 inv02 $PINS Y=nx36862 A=nx37020
Xix36863 inv02 $PINS Y=nx36864 A=nx17196
Xix36865 inv02 $PINS Y=nx36866 A=nx37022
Xix36867 inv02 $PINS Y=nx36868 A=nx37022
Xix36869 inv02 $PINS Y=nx36870 A=nx37022
Xix36871 inv02 $PINS Y=nx36872 A=nx37022
Xix36873 inv02 $PINS Y=nx36874 A=nx37022
Xix36875 inv02 $PINS Y=nx36876 A=nx19970
Xix36877 inv02 $PINS Y=nx36878 A=nx37024
Xix36879 inv02 $PINS Y=nx36880 A=nx37024
Xix36881 inv02 $PINS Y=nx36882 A=nx37024
Xix36883 inv02 $PINS Y=nx36884 A=nx37024
Xix36885 inv02 $PINS Y=nx36886 A=nx37024
Xix36887 inv02 $PINS Y=nx36888 A=nx22744
Xix36889 inv02 $PINS Y=nx36890 A=nx37026
Xix36891 inv02 $PINS Y=nx36892 A=nx37026
Xix36893 inv02 $PINS Y=nx36894 A=nx37026
Xix36895 inv02 $PINS Y=nx36896 A=nx37026
Xix36897 inv02 $PINS Y=nx36898 A=nx37026
Xix36911 inv04 $PINS Y=nx36912 A=nx37422
Xix36915 inv02 $PINS Y=nx36916 A=nx23298
Xix36917 inv02 $PINS Y=nx36918 A=nx23298
Xix36919 inv02 $PINS Y=nx36920 A=nx23298
Xix36921 inv02 $PINS Y=nx36922 A=nx36804
Xix36923 inv02 $PINS Y=nx36924 A=nx23290
Xix36925 inv02 $PINS Y=nx36926 A=nx23290
Xix36927 inv02 $PINS Y=nx36928 A=nx23290
Xix36929 inv02 $PINS Y=nx36930 A=nx23279
Xix36931 inv02 $PINS Y=nx36932 A=nx23279
Xix36933 inv02 $PINS Y=nx36934 A=nx23279
Xix36935 inv02 $PINS Y=nx36936 A=nx23267
Xix36937 inv02 $PINS Y=nx36938 A=nx23267
Xix36939 inv02 $PINS Y=nx36940 A=nx23267
Xix36941 inv02 $PINS Y=nx36942 A=nx36208
Xix36943 inv02 $PINS Y=nx36944 A=nx36208
Xix36945 inv02 $PINS Y=nx36946 A=nx36208
Xix36947 inv02 $PINS Y=nx36948 A=nx36248
Xix36949 inv02 $PINS Y=nx36950 A=nx36248
Xix36951 inv02 $PINS Y=nx36952 A=nx36248
Xix36953 inv02 $PINS Y=nx36954 A=nx36168
Xix36955 inv02 $PINS Y=nx36956 A=nx36168
Xix36957 inv02 $PINS Y=nx36958 A=nx36168
Xix36959 inv02 $PINS Y=nx36960 A=nx36128
Xix36961 inv02 $PINS Y=nx36962 A=nx36128
Xix36963 inv02 $PINS Y=nx36964 A=nx36128
Xix36965 inv02 $PINS Y=nx36966 A=nx36048
Xix36967 inv02 $PINS Y=nx36968 A=nx36048
Xix36969 inv02 $PINS Y=nx36970 A=nx36048
Xix36971 inv02 $PINS Y=nx36972 A=nx36088
Xix36973 inv02 $PINS Y=nx36974 A=nx36088
Xix36975 inv02 $PINS Y=nx36976 A=nx36088
Xix36977 inv02 $PINS Y=nx36978 A=nx36008
Xix36979 inv02 $PINS Y=nx36980 A=nx36008
Xix36981 inv02 $PINS Y=nx36982 A=nx36008
Xix36983 inv02 $PINS Y=nx36984 A=nx35968
Xix36985 inv02 $PINS Y=nx36986 A=nx35968
Xix36987 inv02 $PINS Y=nx36988 A=nx35968
Xix36989 inv02 $PINS Y=nx36990 A=nx35928
Xix36991 inv02 $PINS Y=nx36992 A=nx35928
Xix36993 inv02 $PINS Y=nx36994 A=nx35928
Xix36995 inv02 $PINS Y=nx36996 A=nx35888
Xix36997 inv02 $PINS Y=nx36998 A=nx35888
Xix36999 inv02 $PINS Y=nx37000 A=nx35888
Xix37001 inv02 $PINS Y=nx37002 A=nx35848
Xix37003 inv02 $PINS Y=nx37004 A=nx35848
Xix37005 inv02 $PINS Y=nx37006 A=nx35848
Xix37007 inv02 $PINS Y=nx37008 A=nx35808
Xix37009 inv02 $PINS Y=nx37010 A=nx35808
Xix37011 inv02 $PINS Y=nx37012 A=nx35808
Xix37013 inv02 $PINS Y=nx37014 A=nx36816
Xix37015 inv02 $PINS Y=nx37016 A=nx36828
Xix37017 inv02 $PINS Y=nx37018 A=nx36840
Xix37019 inv02 $PINS Y=nx37020 A=nx36852
Xix37021 inv02 $PINS Y=nx37022 A=nx36864
Xix37023 inv02 $PINS Y=nx37024 A=nx36876
Xix37025 inv02 $PINS Y=nx37026 A=nx36888
Xix37027 inv04 $PINS Y=nx37028 A=camera_module_write_from_DMA
Xix37029 inv02 $PINS Y=nx37030 A=nx1490
Xix37031 inv02 $PINS Y=nx37032 A=nx1472
Xix37033 inv02 $PINS Y=nx37034 A=nx1452
Xix37035 inv02 $PINS Y=nx37036 A=nx1434
Xix37037 inv02 $PINS Y=nx37038 A=nx1410
Xix37039 inv02 $PINS Y=nx37040 A=nx1392
Xix37041 inv02 $PINS Y=nx37042 A=nx1354
Xix37043 inv02 $PINS Y=nx37044 A=nx1372
Xix37045 inv02 $PINS Y=nx37046 A=nx1326
Xix37047 inv02 $PINS Y=nx37048 A=nx1308
Xix37049 inv02 $PINS Y=nx37050 A=nx1270
Xix37051 inv02 $PINS Y=nx37052 A=nx1288
Xix27167 mux21 $PINS Y=nx27166 A0=nx35670 A1=motor_direction[0] S0=nx37146
Xix22580 and02 $PINS Y=nx22579 A0=nx22585 A1=nx22943
Xix22588 or03 $PINS Y=nx22587 A0=rst A1=nx22595 A2=nx35698
Xix1044 mux21_ni $PINS Y=nx1043 A0=camera_module_algo_module_pixel_enable
+ A1=nx308 S0=nx879
Xix22524 mux21_ni $PINS Y=nx22523
+ A0=camera_module_algo_module_modCU_current_state_1 A1=nx27106 S0=nx879
Xix27107 nor02ii $PINS Y=nx27106 A0=rst A1=nx37416
Xix22620 nand04 $PINS Y=nx879 A0=nx22565 A1=nx37058 A2=nx34018 A3=nx37060
Xix37057 inv01 $PINS Y=nx37058
+ A=camera_module_algo_module_modCU_current_state_14
Xix37059 inv01 $PINS Y=nx37060 A=nx27132
Xix22632 xnor2 $PINS Y=nx22631 A0=nx33810
+ A1=camera_module_algo_module_prev_cont_value_15
Xix22274 mux21_ni $PINS Y=nx22273
+ A0=camera_module_algo_module_current_cont_value_15 A1=nx26566 S0=nx37306
Xix26567 mux21_ni $PINS Y=nx26566 A0=camera_module_algo_module_Addout_value_15
+ A1=zero S0=nx37074
Xix22264 mux21_ni $PINS Y=nx22263 A0=nx26552
+ A1=camera_module_algo_module_Addout_value_15 S0=nx37118
Xix26553 mux21_ni $PINS Y=nx26552 A0=zero A1=nx26544 S0=nx37146
Xix22214 mux21 $PINS Y=nx22213 A0=nx22653 A1=nx22651 S0=nx37130
Xix22658 oai21 $PINS Y=nx25432 A0=nx33961 A1=nx37062 B0=nx22679
Xix37061 inv01 $PINS Y=nx37062 A=nx22669
Xix22666 and02 $PINS Y=nx22665 A0=nx37136 A1=nx22601
Xix22609 mux21 $PINS Y=nx22608 A0=nx35674 A1=nx22699 S0=nx37136
Xix277 mux21_ni $PINS Y=nx276 A0=zero A1=nx268 S0=nx37124
Xix227 mux21_ni $PINS Y=nx226 A0=zero A1=nx218 S0=nx37124
Xix22767 or04 $PINS Y=nx22766 A0=nx22719 A1=nx37106 A2=nx37098 A3=nx37156
Xix22774 mux21_ni $PINS Y=nx22773 A0=nx35670 A1=nx22775 S0=nx37124
Xix22778 xor2 $PINS Y=nx22777 A0=nx37106 A1=zero
Xix22780 and02 $PINS Y=nx22779 A0=nx37124 A1=nx37172
Xix22788 mux21 $PINS Y=nx22787 A0=zero A1=nx56 S0=nx37126
Xix22792 xor2 $PINS Y=nx22791 A0=nx37156 A1=zero
Xix49 nor03_2x $PINS Y=nx48 A0=nx37064 A1=rst A2=nx22611
Xix37063 inv01 $PINS Y=nx37064 A=camera_module_DMA_module_controlUnit_state_1
Xix22806 mux21 $PINS Y=nx22805 A0=zero A1=nx80 S0=nx37126
Xix79 ao22 $PINS Y=nx78 A0=zero A1=nx37412 B0=one B1=nx37066
Xix37065 inv01 $PINS Y=nx37066 A=nx22791
Xix22812 xor2 $PINS Y=nx22811 A0=nx37098 A1=zero
Xix22816 xor2 $PINS Y=nx22815 A0=nx22821 A1=zero
Xix22824 mux21_ni $PINS Y=nx22823 A0=nx35670 A1=nx22825 S0=nx37126
Xix22832 xor2 $PINS Y=nx22831 A0=nx22835 A1=zero
Xix22838 mux21_ni $PINS Y=nx22837 A0=nx35672 A1=nx22839 S0=nx37126
Xix22847 mux21 $PINS Y=nx22846 A0=zero A1=nx130 S0=nx37126
Xix22850 xor2 $PINS Y=nx22849 A0=nx22719 A1=zero
Xix22852 mux21 $PINS Y=nx22851 A0=nx19958 A1=nx19930 S0=nx37106
Xix19931 mux21_ni $PINS Y=nx19930 A0=nx19926 A1=nx19914 S0=nx37098
Xix19915 mux21_ni $PINS Y=nx19914 A0=nvm_data_118 A1=nvm_data_126 S0=nx37158
Xix19927 mux21_ni $PINS Y=nx19926 A0=nvm_data_102 A1=nvm_data_110 S0=nx37158
Xix19959 mux21_ni $PINS Y=nx19958 A0=nx19954 A1=nx19942 S0=nx37098
Xix19943 mux21_ni $PINS Y=nx19942 A0=nvm_data_86 A1=nvm_data_94 S0=nx37158
Xix19955 mux21_ni $PINS Y=nx19954 A0=nvm_data_70 A1=nvm_data_78 S0=nx37158
Xix19905 mux21_ni $PINS Y=nx19904 A0=nx19872 A1=nx19898 S0=nx37106
Xix19899 mux21_ni $PINS Y=nx19898 A0=nx19894 A1=nx19882 S0=nx37098
Xix19883 mux21_ni $PINS Y=nx19882 A0=nvm_data_54 A1=nvm_data_62 S0=nx37158
Xix19895 mux21_ni $PINS Y=nx19894 A0=nvm_data_38 A1=nvm_data_46 S0=nx37158
Xix22888 mux21 $PINS Y=nx22887 A0=nvm_data_22 A1=nvm_data_30 S0=nx37158
Xix5921 and03 $PINS Y=nx5920 A0=nx37200 A1=nx37436 A2=nx37232
Xix1051 mux21_ni $PINS Y=nx1050 A0=camera_module_cache_address_from_DMA_6
+ A1=nx1042 S0=nx37172
Xix1043 mux21_ni $PINS Y=nx1042 A0=nx1032 A1=nx1038 S0=nx686
Xix22908 xnor2 $PINS Y=nx22907 A0=nx23011 A1=nx35782
Xix529 mux21_ni $PINS Y=nx528 A0=nx520 A1=zero S0=nx37370
Xix471 mux21_ni $PINS Y=nx470 A0=nx462 A1=zero S0=nx37370
Xix22932 xnor2 $PINS Y=nx22931 A0=nx22935 A1=nx35782
Xix1084 mux21_ni $PINS Y=nx1083
+ A0=camera_module_algo_module_modCU_current_state_7 A1=nx348 S0=nx879
Xix349 nor02ii $PINS Y=nx348 A0=rst
+ A1=camera_module_algo_module_modCU_current_state_6
Xix22952 xor2 $PINS Y=nx22951 A0=camera_module_algo_module_address_value_2
+ A1=nx35782
Xix22954 nor02ii $PINS Y=nx22953 A0=camera_module_algo_module_prev_cont_enable
+ A1=nx37138
Xix22504 mux21_ni $PINS Y=nx22503 A0=motor_move A1=nx27084 S0=nx879
Xix27069 mux21_ni $PINS Y=nx27068 A0=zero A1=one S0=nx37138
Xix22974 and02 $PINS Y=nx22973 A0=nx37406 A1=nx22979
Xix22982 or03 $PINS Y=nx22981 A0=rst A1=nx22987 A2=nx35698
Xix22990 or03 $PINS Y=nx22989 A0=rst A1=nx22993 A2=nx35698
Xix22998 xnor2 $PINS Y=nx22997 A0=nx23005 A1=nx35782
Xix23007 xor2 $PINS Y=nx23006 A0=camera_module_algo_module_address_value_4
+ A1=nx35782
Xix23027 xor2 $PINS Y=nx23026 A0=nx23021 A1=one
Xix23034 xor2 $PINS Y=nx23033 A0=camera_module_algo_module_address_value_6
+ A1=nx35784
Xix577 mux21_ni $PINS Y=nx576 A0=nx568 A1=zero S0=nx37370
Xix1033 mux21_ni $PINS Y=nx1032 A0=camera_module_algo_module_address_value_6
+ A1=nx568 S0=nx37082
Xix23044 nand02 $PINS Y=nx688 A0=nx22597 A1=nx22943
Xix23047 nand02_2x $PINS Y=nx686 A0=nx22585 A1=nx22987
Xix1025 mux21_ni $PINS Y=nx1024 A0=camera_module_cache_address_from_DMA_7
+ A1=nx1016 S0=nx37172
Xix23052 mux21_ni $PINS Y=nx23051 A0=nx23067 A1=nx23053 S0=nx37082
Xix23060 xnor2 $PINS Y=nx23059 A0=nx23067 A1=nx35784
Xix981 mux21_ni $PINS Y=nx980 A0=camera_module_cache_address_from_DMA_4
+ A1=nx972 S0=nx37172
Xix973 mux21_ni $PINS Y=nx972 A0=nx962 A1=nx968 S0=nx686
Xix963 mux21_ni $PINS Y=nx962 A0=camera_module_algo_module_address_value_4
+ A1=nx520 S0=nx37082
Xix955 mux21_ni $PINS Y=nx954 A0=camera_module_cache_address_from_DMA_5
+ A1=nx946 S0=nx37172
Xix23085 mux21_ni $PINS Y=nx23084 A0=nx23011 A1=nx22912 S0=nx37082
Xix907 mux21_ni $PINS Y=nx906 A0=nx34112 A1=nx898 S0=nx37174
Xix899 mux21_ni $PINS Y=nx898 A0=nx888 A1=nx894 S0=nx686
Xix889 mux21_ni $PINS Y=nx888 A0=camera_module_algo_module_address_value_2
+ A1=nx462 S0=nx37084
Xix881 mux21_ni $PINS Y=nx880 A0=nx34072 A1=nx872 S0=nx37174
Xix23101 mux21_ni $PINS Y=nx23100 A0=nx23005 A1=nx23003 S0=nx37084
Xix837 mux21_ni $PINS Y=nx836 A0=nx34080 A1=nx828 S0=nx37174
Xix23112 mux21_ni $PINS Y=nx23111 A0=nx23021 A1=nx23026 S0=nx37084
Xix23114 xor2 $PINS Y=nx23113 A0=nx23021 A1=zero
Xix811 mux21_ni $PINS Y=nx810 A0=nx34100 A1=nx802 S0=nx37174
Xix23118 mux21_ni $PINS Y=nx23117 A0=nx22935 A1=nx22575 S0=nx37084
Xix5905 and03 $PINS Y=nx5904 A0=nx37202 A1=nx37436 A2=nx37232
Xix23131 nor02ii $PINS Y=nx23130 A0=nx954 A1=nx980
Xix5887 and03 $PINS Y=nx5886 A0=nx37204 A1=nx37436 A2=nx37232
Xix23146 nor02ii $PINS Y=nx23145 A0=nx980 A1=nx954
Xix5871 and03 $PINS Y=nx5870 A0=nx37206 A1=nx37436 A2=nx37232
Xix5851 and03 $PINS Y=nx5850 A0=nx37208 A1=nx37436 A2=nx37232
Xix23173 nor02ii $PINS Y=nx23172 A0=nx1024 A1=nx1050
Xix5835 and03 $PINS Y=nx5834 A0=nx37210 A1=nx37436 A2=nx37232
Xix5801 and03 $PINS Y=nx5800 A0=nx37212 A1=nx37312 A2=nx37234
Xix5817 and03 $PINS Y=nx5816 A0=nx37214 A1=nx37312 A2=nx37234
Xix5779 and03 $PINS Y=nx5778 A0=nx37216 A1=nx37312 A2=nx37234
Xix23219 nor02ii $PINS Y=nx23218 A0=nx1050 A1=nx1024
Xix5763 and03 $PINS Y=nx5762 A0=nx37218 A1=nx37312 A2=nx37234
Xix5729 and03 $PINS Y=nx5728 A0=nx37220 A1=nx37312 A2=nx37234
Xix5745 and03 $PINS Y=nx5744 A0=nx37222 A1=nx37312 A2=nx37234
Xix5709 and03 $PINS Y=nx5708 A0=nx37224 A1=nx37312 A2=nx37234
Xix23268 nor02ii $PINS Y=nx23267 A0=nx1056 A1=nx23073
Xix5693 and03 $PINS Y=nx5692 A0=nx37226 A1=nx37314 A2=nx36450
Xix23280 nor02ii $PINS Y=nx23279 A0=nx1056 A1=nx23130
Xix5675 and03 $PINS Y=nx5674 A0=nx37228 A1=nx37314 A2=nx36450
Xix23291 nor02ii $PINS Y=nx23290 A0=nx1056 A1=nx23145
Xix5659 and03 $PINS Y=nx5658 A0=nx37230 A1=nx37314 A2=nx36450
Xix5629 and03 $PINS Y=nx5628 A0=nx37236 A1=nx37314 A2=nx35844
Xix23315 nor02ii $PINS Y=nx23314 A0=nx810 A1=nx836
Xix5613 and03 $PINS Y=nx5612 A0=nx35884 A1=nx37314 A2=nx37236
Xix5595 and03 $PINS Y=nx5594 A0=nx35924 A1=nx37314 A2=nx37236
Xix5579 and03 $PINS Y=nx5578 A0=nx35964 A1=nx37314 A2=nx37236
Xix5559 and03 $PINS Y=nx5558 A0=nx36004 A1=nx37316 A2=nx37236
Xix5543 and03 $PINS Y=nx5542 A0=nx36044 A1=nx37316 A2=nx37236
Xix5509 and03 $PINS Y=nx5508 A0=nx36084 A1=nx37316 A2=nx37238
Xix5525 and03 $PINS Y=nx5524 A0=nx36124 A1=nx37316 A2=nx37238
Xix5487 and03 $PINS Y=nx5486 A0=nx36164 A1=nx37316 A2=nx37238
Xix5471 and03 $PINS Y=nx5470 A0=nx36204 A1=nx37316 A2=nx37238
Xix5437 and03 $PINS Y=nx5436 A0=nx36244 A1=nx37316 A2=nx37238
Xix5453 and03 $PINS Y=nx5452 A0=nx36284 A1=nx37318 A2=nx37238
Xix5417 and03 $PINS Y=nx5416 A0=nx36324 A1=nx37318 A2=nx37238
Xix5401 and03 $PINS Y=nx5400 A0=nx36364 A1=nx37318 A2=nx36454
Xix5383 and03 $PINS Y=nx5382 A0=nx36404 A1=nx37318 A2=nx36454
Xix5367 and03 $PINS Y=nx5366 A0=nx36444 A1=nx37318 A2=nx36454
Xix5335 and03 $PINS Y=nx5334 A0=nx37240 A1=nx37318 A2=nx35844
Xix23424 nor02ii $PINS Y=nx23423 A0=nx836 A1=nx810
Xix5319 and03 $PINS Y=nx5318 A0=nx35884 A1=nx37318 A2=nx37240
Xix5301 and03 $PINS Y=nx5300 A0=nx35924 A1=nx37320 A2=nx37240
Xix5285 and03 $PINS Y=nx5284 A0=nx35964 A1=nx37320 A2=nx37240
Xix5265 and03 $PINS Y=nx5264 A0=nx36004 A1=nx37320 A2=nx37240
Xix5249 and03 $PINS Y=nx5248 A0=nx36044 A1=nx37320 A2=nx37240
Xix5215 and03 $PINS Y=nx5214 A0=nx36084 A1=nx37320 A2=nx37242
Xix5231 and03 $PINS Y=nx5230 A0=nx36124 A1=nx37320 A2=nx37242
Xix5193 and03 $PINS Y=nx5192 A0=nx36164 A1=nx37320 A2=nx37242
Xix5177 and03 $PINS Y=nx5176 A0=nx36204 A1=nx37322 A2=nx37242
Xix5143 and03 $PINS Y=nx5142 A0=nx36244 A1=nx37322 A2=nx37242
Xix5159 and03 $PINS Y=nx5158 A0=nx36284 A1=nx37322 A2=nx37242
Xix5123 and03 $PINS Y=nx5122 A0=nx36324 A1=nx37322 A2=nx37242
Xix5107 and03 $PINS Y=nx5106 A0=nx36364 A1=nx37322 A2=nx36458
Xix5089 and03 $PINS Y=nx5088 A0=nx36404 A1=nx37322 A2=nx36458
Xix5073 and03 $PINS Y=nx5072 A0=nx36444 A1=nx37322 A2=nx36458
Xix5043 and03 $PINS Y=nx5042 A0=nx37244 A1=nx37324 A2=nx35844
Xix5027 and03 $PINS Y=nx5026 A0=nx35884 A1=nx37324 A2=nx37244
Xix5009 and03 $PINS Y=nx5008 A0=nx35924 A1=nx37324 A2=nx37244
Xix4993 and03 $PINS Y=nx4992 A0=nx35964 A1=nx37324 A2=nx37244
Xix4973 and03 $PINS Y=nx4972 A0=nx36004 A1=nx37324 A2=nx37244
Xix4957 and03 $PINS Y=nx4956 A0=nx36044 A1=nx37324 A2=nx37244
Xix4923 and03 $PINS Y=nx4922 A0=nx36084 A1=nx37324 A2=nx37246
Xix4939 and03 $PINS Y=nx4938 A0=nx36124 A1=nx37326 A2=nx37246
Xix4901 and03 $PINS Y=nx4900 A0=nx36164 A1=nx37326 A2=nx37246
Xix4885 and03 $PINS Y=nx4884 A0=nx36204 A1=nx37326 A2=nx37246
Xix4851 and03 $PINS Y=nx4850 A0=nx36244 A1=nx37326 A2=nx37246
Xix4867 and03 $PINS Y=nx4866 A0=nx36284 A1=nx37326 A2=nx37246
Xix4831 and03 $PINS Y=nx4830 A0=nx36324 A1=nx37326 A2=nx37246
Xix4815 and03 $PINS Y=nx4814 A0=nx36364 A1=nx37326 A2=nx36462
Xix4797 and03 $PINS Y=nx4796 A0=nx36404 A1=nx37328 A2=nx36462
Xix4781 and03 $PINS Y=nx4780 A0=nx36444 A1=nx37328 A2=nx36462
Xix4745 and03 $PINS Y=nx4744 A0=nx37248 A1=nx37328 A2=nx35844
Xix23640 nor02ii $PINS Y=nx23639 A0=nx880 A1=nx906
Xix4729 and03 $PINS Y=nx4728 A0=nx35884 A1=nx37328 A2=nx37248
Xix4711 and03 $PINS Y=nx4710 A0=nx35924 A1=nx37328 A2=nx37248
Xix4695 and03 $PINS Y=nx4694 A0=nx35964 A1=nx37328 A2=nx37248
Xix4675 and03 $PINS Y=nx4674 A0=nx36004 A1=nx37328 A2=nx37248
Xix4659 and03 $PINS Y=nx4658 A0=nx36044 A1=nx37330 A2=nx37248
Xix4625 and03 $PINS Y=nx4624 A0=nx36084 A1=nx37330 A2=nx37250
Xix4641 and03 $PINS Y=nx4640 A0=nx36124 A1=nx37330 A2=nx37250
Xix4603 and03 $PINS Y=nx4602 A0=nx36164 A1=nx37330 A2=nx37250
Xix4587 and03 $PINS Y=nx4586 A0=nx36204 A1=nx37330 A2=nx37250
Xix4553 and03 $PINS Y=nx4552 A0=nx36244 A1=nx37330 A2=nx37250
Xix4569 and03 $PINS Y=nx4568 A0=nx36284 A1=nx37330 A2=nx37250
Xix4533 and03 $PINS Y=nx4532 A0=nx36324 A1=nx37332 A2=nx37250
Xix4517 and03 $PINS Y=nx4516 A0=nx36364 A1=nx37332 A2=nx36466
Xix4499 and03 $PINS Y=nx4498 A0=nx36404 A1=nx37332 A2=nx36466
Xix4483 and03 $PINS Y=nx4482 A0=nx36444 A1=nx37332 A2=nx36466
Xix4453 and03 $PINS Y=nx4452 A0=nx37252 A1=nx37332 A2=nx35844
Xix4437 and03 $PINS Y=nx4436 A0=nx35884 A1=nx37332 A2=nx37252
Xix4419 and03 $PINS Y=nx4418 A0=nx35924 A1=nx37332 A2=nx37252
Xix4403 and03 $PINS Y=nx4402 A0=nx35964 A1=nx37334 A2=nx37252
Xix4383 and03 $PINS Y=nx4382 A0=nx36004 A1=nx37334 A2=nx37252
Xix4367 and03 $PINS Y=nx4366 A0=nx36044 A1=nx37334 A2=nx37252
Xix4333 and03 $PINS Y=nx4332 A0=nx36084 A1=nx37334 A2=nx37254
Xix4349 and03 $PINS Y=nx4348 A0=nx36124 A1=nx37334 A2=nx37254
Xix4311 and03 $PINS Y=nx4310 A0=nx36164 A1=nx37334 A2=nx37254
Xix4295 and03 $PINS Y=nx4294 A0=nx36204 A1=nx37334 A2=nx37254
Xix4261 and03 $PINS Y=nx4260 A0=nx36244 A1=nx37336 A2=nx37254
Xix4277 and03 $PINS Y=nx4276 A0=nx36284 A1=nx37336 A2=nx37254
Xix4241 and03 $PINS Y=nx4240 A0=nx36324 A1=nx37336 A2=nx37254
Xix4225 and03 $PINS Y=nx4224 A0=nx36364 A1=nx37336 A2=nx36470
Xix4207 and03 $PINS Y=nx4206 A0=nx36404 A1=nx37336 A2=nx36470
Xix4191 and03 $PINS Y=nx4190 A0=nx36444 A1=nx37336 A2=nx36470
Xix4159 and03 $PINS Y=nx4158 A0=nx37256 A1=nx37336 A2=nx35846
Xix4143 and03 $PINS Y=nx4142 A0=nx35884 A1=nx37338 A2=nx37256
Xix4125 and03 $PINS Y=nx4124 A0=nx35924 A1=nx37338 A2=nx37256
Xix4109 and03 $PINS Y=nx4108 A0=nx35964 A1=nx37338 A2=nx37256
Xix4089 and03 $PINS Y=nx4088 A0=nx36004 A1=nx37338 A2=nx37256
Xix4073 and03 $PINS Y=nx4072 A0=nx36044 A1=nx37338 A2=nx37256
Xix4039 and03 $PINS Y=nx4038 A0=nx36084 A1=nx37338 A2=nx37258
Xix4055 and03 $PINS Y=nx4054 A0=nx36124 A1=nx37338 A2=nx37258
Xix4017 and03 $PINS Y=nx4016 A0=nx36164 A1=nx37340 A2=nx37258
Xix4001 and03 $PINS Y=nx4000 A0=nx36204 A1=nx37340 A2=nx37258
Xix3967 and03 $PINS Y=nx3966 A0=nx36244 A1=nx37340 A2=nx37258
Xix3983 and03 $PINS Y=nx3982 A0=nx36284 A1=nx37340 A2=nx37258
Xix3947 and03 $PINS Y=nx3946 A0=nx36324 A1=nx37340 A2=nx37258
Xix3931 and03 $PINS Y=nx3930 A0=nx36364 A1=nx37340 A2=nx36474
Xix3913 and03 $PINS Y=nx3912 A0=nx36404 A1=nx37340 A2=nx36474
Xix3897 and03 $PINS Y=nx3896 A0=nx36444 A1=nx37342 A2=nx36474
Xix3867 and03 $PINS Y=nx3866 A0=nx37260 A1=nx37342 A2=nx35846
Xix3851 and03 $PINS Y=nx3850 A0=nx35886 A1=nx37342 A2=nx37260
Xix3833 and03 $PINS Y=nx3832 A0=nx35926 A1=nx37342 A2=nx37260
Xix3817 and03 $PINS Y=nx3816 A0=nx35966 A1=nx37342 A2=nx37260
Xix3797 and03 $PINS Y=nx3796 A0=nx36006 A1=nx37342 A2=nx37260
Xix3781 and03 $PINS Y=nx3780 A0=nx36046 A1=nx37342 A2=nx37260
Xix3747 and03 $PINS Y=nx3746 A0=nx36086 A1=nx37344 A2=nx37262
Xix3763 and03 $PINS Y=nx3762 A0=nx36126 A1=nx37344 A2=nx37262
Xix3725 and03 $PINS Y=nx3724 A0=nx36166 A1=nx37344 A2=nx37262
Xix3709 and03 $PINS Y=nx3708 A0=nx36206 A1=nx37344 A2=nx37262
Xix3675 and03 $PINS Y=nx3674 A0=nx36246 A1=nx37344 A2=nx37262
Xix3691 and03 $PINS Y=nx3690 A0=nx36286 A1=nx37344 A2=nx37262
Xix3655 and03 $PINS Y=nx3654 A0=nx36326 A1=nx37344 A2=nx37262
Xix3639 and03 $PINS Y=nx3638 A0=nx36366 A1=nx37346 A2=nx36478
Xix3621 and03 $PINS Y=nx3620 A0=nx36406 A1=nx37346 A2=nx36478
Xix3605 and03 $PINS Y=nx3604 A0=nx36446 A1=nx37346 A2=nx36478
Xix3565 and03 $PINS Y=nx3564 A0=nx37264 A1=nx37346 A2=nx35846
Xix24054 nor02ii $PINS Y=nx24053 A0=nx906 A1=nx880
Xix3549 and03 $PINS Y=nx3548 A0=nx35886 A1=nx37346 A2=nx37264
Xix3531 and03 $PINS Y=nx3530 A0=nx35926 A1=nx37346 A2=nx37264
Xix3515 and03 $PINS Y=nx3514 A0=nx35966 A1=nx37346 A2=nx37264
Xix3495 and03 $PINS Y=nx3494 A0=nx36006 A1=nx37348 A2=nx37264
Xix3479 and03 $PINS Y=nx3478 A0=nx36046 A1=nx37348 A2=nx37264
Xix3445 and03 $PINS Y=nx3444 A0=nx36086 A1=nx37348 A2=nx37266
Xix3461 and03 $PINS Y=nx3460 A0=nx36126 A1=nx37348 A2=nx37266
Xix3423 and03 $PINS Y=nx3422 A0=nx36166 A1=nx37348 A2=nx37266
Xix3407 and03 $PINS Y=nx3406 A0=nx36206 A1=nx37348 A2=nx37266
Xix3373 and03 $PINS Y=nx3372 A0=nx36246 A1=nx37348 A2=nx37266
Xix3389 and03 $PINS Y=nx3388 A0=nx36286 A1=nx37350 A2=nx37266
Xix3353 and03 $PINS Y=nx3352 A0=nx36326 A1=nx37350 A2=nx37266
Xix3337 and03 $PINS Y=nx3336 A0=nx36366 A1=nx37350 A2=nx36482
Xix3319 and03 $PINS Y=nx3318 A0=nx36406 A1=nx37350 A2=nx36482
Xix3303 and03 $PINS Y=nx3302 A0=nx36446 A1=nx37350 A2=nx36482
Xix3273 and03 $PINS Y=nx3272 A0=nx37268 A1=nx37350 A2=nx35846
Xix3257 and03 $PINS Y=nx3256 A0=nx35886 A1=nx37350 A2=nx37268
Xix3239 and03 $PINS Y=nx3238 A0=nx35926 A1=nx37352 A2=nx37268
Xix3223 and03 $PINS Y=nx3222 A0=nx35966 A1=nx37352 A2=nx37268
Xix3203 and03 $PINS Y=nx3202 A0=nx36006 A1=nx37352 A2=nx37268
Xix3187 and03 $PINS Y=nx3186 A0=nx36046 A1=nx37352 A2=nx37268
Xix3153 and03 $PINS Y=nx3152 A0=nx36086 A1=nx37352 A2=nx37270
Xix3169 and03 $PINS Y=nx3168 A0=nx36126 A1=nx37352 A2=nx37270
Xix3131 and03 $PINS Y=nx3130 A0=nx36166 A1=nx37352 A2=nx37270
Xix3115 and03 $PINS Y=nx3114 A0=nx36206 A1=nx37354 A2=nx37270
Xix3081 and03 $PINS Y=nx3080 A0=nx36246 A1=nx37354 A2=nx37270
Xix3097 and03 $PINS Y=nx3096 A0=nx36286 A1=nx37354 A2=nx37270
Xix3061 and03 $PINS Y=nx3060 A0=nx36326 A1=nx37354 A2=nx37270
Xix3045 and03 $PINS Y=nx3044 A0=nx36366 A1=nx37354 A2=nx36486
Xix3027 and03 $PINS Y=nx3026 A0=nx36406 A1=nx37356 A2=nx36486
Xix3011 and03 $PINS Y=nx3010 A0=nx36446 A1=nx37356 A2=nx36486
Xix2979 and03 $PINS Y=nx2978 A0=nx37272 A1=nx37356 A2=nx35846
Xix2963 and03 $PINS Y=nx2962 A0=nx35886 A1=nx37356 A2=nx37272
Xix2945 and03 $PINS Y=nx2944 A0=nx35926 A1=nx37356 A2=nx37272
Xix2929 and03 $PINS Y=nx2928 A0=nx35966 A1=nx37356 A2=nx37272
Xix2909 and03 $PINS Y=nx2908 A0=nx36006 A1=nx37356 A2=nx37272
Xix2893 and03 $PINS Y=nx2892 A0=nx36046 A1=nx37358 A2=nx37272
Xix2859 and03 $PINS Y=nx2858 A0=nx36086 A1=nx37358 A2=nx37274
Xix2875 and03 $PINS Y=nx2874 A0=nx36126 A1=nx37358 A2=nx37274
Xix2837 and03 $PINS Y=nx2836 A0=nx36166 A1=nx37358 A2=nx37274
Xix2821 and03 $PINS Y=nx2820 A0=nx36206 A1=nx37358 A2=nx37274
Xix2787 and03 $PINS Y=nx2786 A0=nx36246 A1=nx37358 A2=nx37274
Xix2803 and03 $PINS Y=nx2802 A0=nx36286 A1=nx37358 A2=nx37274
Xix2767 and03 $PINS Y=nx2766 A0=nx36326 A1=nx37360 A2=nx37274
Xix2751 and03 $PINS Y=nx2750 A0=nx36366 A1=nx37360 A2=nx36490
Xix2733 and03 $PINS Y=nx2732 A0=nx36406 A1=nx37360 A2=nx36490
Xix2717 and03 $PINS Y=nx2716 A0=nx36446 A1=nx37360 A2=nx36490
Xix2687 and03 $PINS Y=nx2686 A0=nx37276 A1=nx37360 A2=nx35846
Xix2671 and03 $PINS Y=nx2670 A0=nx35886 A1=nx37360 A2=nx37276
Xix2653 and03 $PINS Y=nx2652 A0=nx35926 A1=nx37360 A2=nx37276
Xix2637 and03 $PINS Y=nx2636 A0=nx35966 A1=nx37362 A2=nx37276
Xix2617 and03 $PINS Y=nx2616 A0=nx36006 A1=nx37362 A2=nx37276
Xix2601 and03 $PINS Y=nx2600 A0=nx36046 A1=nx37362 A2=nx37276
Xix2567 and03 $PINS Y=nx2566 A0=nx36086 A1=nx37362 A2=nx37278
Xix2583 and03 $PINS Y=nx2582 A0=nx36126 A1=nx37362 A2=nx37278
Xix2545 and03 $PINS Y=nx2544 A0=nx36166 A1=nx37362 A2=nx37278
Xix2529 and03 $PINS Y=nx2528 A0=nx36206 A1=nx37362 A2=nx37278
Xix2495 and03 $PINS Y=nx2494 A0=nx36246 A1=nx37364 A2=nx37278
Xix2511 and03 $PINS Y=nx2510 A0=nx36286 A1=nx37364 A2=nx37278
Xix2475 and03 $PINS Y=nx2474 A0=nx36326 A1=nx37364 A2=nx37278
Xix2459 and03 $PINS Y=nx2458 A0=nx36366 A1=nx37364 A2=nx36494
Xix2441 and03 $PINS Y=nx2440 A0=nx36406 A1=nx37364 A2=nx36494
Xix2425 and03 $PINS Y=nx2424 A0=nx36446 A1=nx37364 A2=nx36494
Xix24464 or03 $PINS Y=nx24463 A0=nx37280 A1=nx37174 A2=nx37008
Xix24466 nand02 $PINS Y=nx36500 A0=nx37068 A1=nx23105
Xix37067 inv01 $PINS Y=nx37068 A=nx912
Xix24474 or03 $PINS Y=nx24473 A0=nx37002 A1=nx37174 A2=nx37280
Xix24482 or03 $PINS Y=nx24481 A0=nx36996 A1=nx37174 A2=nx37280
Xix24488 or03 $PINS Y=nx24487 A0=nx36990 A1=nx37176 A2=nx37280
Xix24496 or03 $PINS Y=nx24495 A0=nx36984 A1=nx37176 A2=nx37280
Xix24501 or03 $PINS Y=nx24500 A0=nx36978 A1=nx37178 A2=nx37280
Xix24509 or03 $PINS Y=nx24508 A0=nx36966 A1=nx37178 A2=nx37282
Xix24514 or03 $PINS Y=nx24513 A0=nx36972 A1=nx37178 A2=nx37282
Xix24522 or03 $PINS Y=nx24521 A0=nx36960 A1=nx37178 A2=nx37282
Xix24527 or03 $PINS Y=nx24526 A0=nx36954 A1=nx37178 A2=nx37282
Xix24536 or03 $PINS Y=nx24535 A0=nx36942 A1=nx37178 A2=nx37282
Xix24542 or03 $PINS Y=nx24541 A0=nx36948 A1=nx37178 A2=nx37282
Xix24549 or03 $PINS Y=nx24548 A0=nx36936 A1=nx37180 A2=nx37282
Xix24555 or03 $PINS Y=nx24554 A0=nx36930 A1=nx37180 A2=nx37284
Xix24564 or03 $PINS Y=nx24563 A0=nx36924 A1=nx37180 A2=nx37284
Xix24570 or03 $PINS Y=nx24569 A0=nx36916 A1=nx37180 A2=nx37284
Xix24582 or03 $PINS Y=nx24581 A0=nx37286 A1=nx37180 A2=nx37008
Xix24584 nand02 $PINS Y=nx36574 A0=nx37068 A1=nx23314
Xix24590 or03 $PINS Y=nx24589 A0=nx37002 A1=nx37180 A2=nx37286
Xix24598 or03 $PINS Y=nx24597 A0=nx36996 A1=nx37180 A2=nx37286
Xix24603 or03 $PINS Y=nx24602 A0=nx36990 A1=nx37182 A2=nx37286
Xix24611 or03 $PINS Y=nx24610 A0=nx36984 A1=nx37182 A2=nx37286
Xix24616 or03 $PINS Y=nx24615 A0=nx36978 A1=nx37182 A2=nx37286
Xix24625 or03 $PINS Y=nx24624 A0=nx36966 A1=nx37182 A2=nx37288
Xix24630 or03 $PINS Y=nx24629 A0=nx36972 A1=nx37182 A2=nx37288
Xix24638 or03 $PINS Y=nx24637 A0=nx36960 A1=nx37182 A2=nx37288
Xix24643 or03 $PINS Y=nx24642 A0=nx36954 A1=nx37182 A2=nx37288
Xix24651 or03 $PINS Y=nx24650 A0=nx36942 A1=nx37184 A2=nx37288
Xix24656 or03 $PINS Y=nx24655 A0=nx36948 A1=nx37184 A2=nx37288
Xix24664 or03 $PINS Y=nx24663 A0=nx36936 A1=nx37184 A2=nx37288
Xix24670 or03 $PINS Y=nx24669 A0=nx36930 A1=nx37184 A2=nx37290
Xix24678 or03 $PINS Y=nx24677 A0=nx36924 A1=nx37184 A2=nx37290
Xix24683 or03 $PINS Y=nx24682 A0=nx36916 A1=nx37184 A2=nx37290
Xix24694 or03 $PINS Y=nx24693 A0=nx37292 A1=nx37184 A2=nx37008
Xix24696 nand02 $PINS Y=nx36648 A0=nx37068 A1=nx23423
Xix24704 or03 $PINS Y=nx24703 A0=nx37002 A1=nx37186 A2=nx37292
Xix24713 or03 $PINS Y=nx24712 A0=nx36996 A1=nx37186 A2=nx37292
Xix24718 or03 $PINS Y=nx24717 A0=nx36990 A1=nx37186 A2=nx37292
Xix24726 or03 $PINS Y=nx24725 A0=nx36984 A1=nx37186 A2=nx37292
Xix24731 or03 $PINS Y=nx24730 A0=nx36978 A1=nx37186 A2=nx37292
Xix24739 or03 $PINS Y=nx24738 A0=nx36966 A1=nx37186 A2=nx37294
Xix24744 or03 $PINS Y=nx24743 A0=nx36972 A1=nx37186 A2=nx37294
Xix24752 or03 $PINS Y=nx24751 A0=nx36960 A1=nx37188 A2=nx37294
Xix24758 or03 $PINS Y=nx24757 A0=nx36954 A1=nx37188 A2=nx37294
Xix24766 or03 $PINS Y=nx24765 A0=nx36942 A1=nx37188 A2=nx37294
Xix24771 or03 $PINS Y=nx24770 A0=nx36948 A1=nx37188 A2=nx37294
Xix24779 or03 $PINS Y=nx24778 A0=nx36936 A1=nx37188 A2=nx37294
Xix24786 or03 $PINS Y=nx24785 A0=nx36930 A1=nx37188 A2=nx37296
Xix24793 or03 $PINS Y=nx24792 A0=nx36924 A1=nx37188 A2=nx37296
Xix24799 or03 $PINS Y=nx24798 A0=nx36916 A1=nx37190 A2=nx37296
Xix24810 or03 $PINS Y=nx24809 A0=nx37298 A1=nx37190 A2=nx37008
Xix24817 or03 $PINS Y=nx24816 A0=nx37002 A1=nx37190 A2=nx37298
Xix24826 or03 $PINS Y=nx24825 A0=nx36996 A1=nx37190 A2=nx37298
Xix24831 or03 $PINS Y=nx24830 A0=nx36990 A1=nx37190 A2=nx37298
Xix24839 or03 $PINS Y=nx24838 A0=nx36984 A1=nx37190 A2=nx37298
Xix24846 or03 $PINS Y=nx24845 A0=nx36978 A1=nx37190 A2=nx37300
Xix24854 or03 $PINS Y=nx24853 A0=nx36966 A1=nx37192 A2=nx37300
Xix24860 or03 $PINS Y=nx24859 A0=nx36972 A1=nx37192 A2=nx37300
Xix24870 or03 $PINS Y=nx24869 A0=nx36960 A1=nx37192 A2=nx37300
Xix24875 or03 $PINS Y=nx24874 A0=nx36954 A1=nx37192 A2=nx37300
Xix24883 or03 $PINS Y=nx24882 A0=nx36942 A1=nx37192 A2=nx37300
Xix24888 or03 $PINS Y=nx24887 A0=nx36948 A1=nx37192 A2=nx37300
Xix24895 or03 $PINS Y=nx24894 A0=nx36936 A1=nx37192 A2=nx37302
Xix24901 or03 $PINS Y=nx24900 A0=nx36930 A1=nx37194 A2=nx37302
Xix24910 or03 $PINS Y=nx24909 A0=nx36924 A1=nx37194 A2=nx37302
Xix24915 or03 $PINS Y=nx24914 A0=nx36916 A1=nx37194 A2=nx37302
Xix24922 mux21 $PINS Y=nx24921 A0=camera_module_algo_module_address_value_1
+ A1=nx23005 S0=camera_module_algo_module_address_value_2
Xix753 ao32 $PINS Y=nx752 A0=nx22935 A1=nx22585 A2=nx22943
+ B0=camera_module_algo_module_address_value_0 B1=nx408
Xix17061 mux21 $PINS Y=nx17060 A0=nx35674 A1=nx24945 S0=nx37138
Xix24961 mux21 $PINS Y=nx24960 A0=nx14410 A1=nx14382 S0=nx37106
Xix14383 mux21_ni $PINS Y=nx14382 A0=nx14378 A1=nx14366 S0=nx37098
Xix14367 mux21_ni $PINS Y=nx14366 A0=nvm_data_116 A1=nvm_data_124 S0=nx37160
Xix14379 mux21_ni $PINS Y=nx14378 A0=nvm_data_100 A1=nvm_data_108 S0=nx37160
Xix14411 mux21_ni $PINS Y=nx14410 A0=nx14406 A1=nx14394 S0=nx37098
Xix14395 mux21_ni $PINS Y=nx14394 A0=nvm_data_84 A1=nvm_data_92 S0=nx37160
Xix14407 mux21_ni $PINS Y=nx14406 A0=nvm_data_68 A1=nvm_data_76 S0=nx37160
Xix14357 mux21_ni $PINS Y=nx14356 A0=nx14324 A1=nx14350 S0=nx37108
Xix14351 mux21_ni $PINS Y=nx14350 A0=nx14346 A1=nx14334 S0=nx37100
Xix14335 mux21_ni $PINS Y=nx14334 A0=nvm_data_52 A1=nvm_data_60 S0=nx37160
Xix14347 mux21_ni $PINS Y=nx14346 A0=nvm_data_36 A1=nvm_data_44 S0=nx37160
Xix24998 mux21 $PINS Y=nx24997 A0=nvm_data_20 A1=nvm_data_28 S0=nx37160
Xix11513 mux21 $PINS Y=nx11512 A0=nx35674 A1=nx26370 S0=nx37138
Xix26386 mux21 $PINS Y=nx26385 A0=nx8862 A1=nx8834 S0=nx37108
Xix8835 mux21_ni $PINS Y=nx8834 A0=nx8830 A1=nx8818 S0=nx37100
Xix8819 mux21_ni $PINS Y=nx8818 A0=nvm_data_114 A1=nvm_data_122 S0=nx37162
Xix8831 mux21_ni $PINS Y=nx8830 A0=nvm_data_98 A1=nvm_data_106 S0=nx37162
Xix8863 mux21_ni $PINS Y=nx8862 A0=nx8858 A1=nx8846 S0=nx37100
Xix8847 mux21_ni $PINS Y=nx8846 A0=nvm_data_82 A1=nvm_data_90 S0=nx37162
Xix8859 mux21_ni $PINS Y=nx8858 A0=nvm_data_66 A1=nvm_data_74 S0=nx37162
Xix8809 mux21_ni $PINS Y=nx8808 A0=nx8776 A1=nx8802 S0=nx37108
Xix8803 mux21_ni $PINS Y=nx8802 A0=nx8798 A1=nx8786 S0=nx37100
Xix8787 mux21_ni $PINS Y=nx8786 A0=nvm_data_50 A1=nvm_data_58 S0=nx37162
Xix8799 mux21_ni $PINS Y=nx8798 A0=nvm_data_34 A1=nvm_data_42 S0=nx37162
Xix26430 mux21 $PINS Y=nx26429 A0=nvm_data_18 A1=nvm_data_26 S0=nx37162
Xix5965 mux21 $PINS Y=nx5964 A0=nx35676 A1=nx27681 S0=nx37138
Xix27695 mux21 $PINS Y=nx27694 A0=nx1174 A1=nx1146 S0=nx37108
Xix1147 mux21_ni $PINS Y=nx1146 A0=nx1142 A1=nx1130 S0=nx37100
Xix1131 mux21_ni $PINS Y=nx1130 A0=nvm_data_112 A1=nvm_data_120 S0=nx37420
Xix1143 mux21_ni $PINS Y=nx1142 A0=nvm_data_96 A1=nvm_data_104 S0=nx37420
Xix1175 mux21_ni $PINS Y=nx1174 A0=nx1170 A1=nx1158 S0=nx37100
Xix1159 mux21_ni $PINS Y=nx1158 A0=nvm_data_80 A1=nvm_data_88 S0=nx37420
Xix1171 mux21_ni $PINS Y=nx1170 A0=nvm_data_64 A1=nvm_data_72 S0=nx37420
Xix1121 mux21_ni $PINS Y=nx1120 A0=nx1088 A1=nx1114 S0=nx37108
Xix1115 mux21_ni $PINS Y=nx1114 A0=nx1110 A1=nx1098 S0=nx37100
Xix1099 mux21_ni $PINS Y=nx1098 A0=nvm_data_48 A1=nvm_data_56 S0=nx37420
Xix1111 mux21_ni $PINS Y=nx1110 A0=nvm_data_32 A1=nvm_data_40 S0=nx37420
Xix27725 mux21 $PINS Y=nx27724 A0=nvm_data_16 A1=nvm_data_24 S0=nx37420
Xix28818 xor2 $PINS Y=nx28817 A0=nx29956 A1=nx28822
Xix8739 mux21 $PINS Y=nx8738 A0=nx35676 A1=nx28822 S0=nx37138
Xix28836 mux21 $PINS Y=nx28835 A0=nx6088 A1=nx6060 S0=nx37108
Xix6061 mux21_ni $PINS Y=nx6060 A0=nx6056 A1=nx6044 S0=nx37102
Xix6045 mux21_ni $PINS Y=nx6044 A0=nvm_data_113 A1=nvm_data_121 S0=nx37164
Xix6057 mux21_ni $PINS Y=nx6056 A0=nvm_data_97 A1=nvm_data_105 S0=nx37164
Xix6089 mux21_ni $PINS Y=nx6088 A0=nx6084 A1=nx6072 S0=nx37102
Xix6073 mux21_ni $PINS Y=nx6072 A0=nvm_data_81 A1=nvm_data_89 S0=nx37164
Xix6085 mux21_ni $PINS Y=nx6084 A0=nvm_data_65 A1=nvm_data_73 S0=nx37166
Xix6035 mux21_ni $PINS Y=nx6034 A0=nx6002 A1=nx6028 S0=nx37108
Xix6029 mux21_ni $PINS Y=nx6028 A0=nx6024 A1=nx6012 S0=nx37102
Xix6013 mux21_ni $PINS Y=nx6012 A0=nvm_data_49 A1=nvm_data_57 S0=nx37166
Xix6025 mux21_ni $PINS Y=nx6024 A0=nvm_data_33 A1=nvm_data_41 S0=nx37166
Xix28866 mux21 $PINS Y=nx28865 A0=nvm_data_17 A1=nvm_data_25 S0=nx37166
Xix29960 xor2 $PINS Y=nx29959 A0=nx31098 A1=nx29964
Xix14287 mux21 $PINS Y=nx14286 A0=nx35676 A1=nx29964 S0=nx37138
Xix29978 mux21 $PINS Y=nx29977 A0=nx11636 A1=nx11608 S0=nx37110
Xix11609 mux21_ni $PINS Y=nx11608 A0=nx11604 A1=nx11592 S0=nx37102
Xix11593 mux21_ni $PINS Y=nx11592 A0=nvm_data_115 A1=nvm_data_123 S0=nx37166
Xix11605 mux21_ni $PINS Y=nx11604 A0=nvm_data_99 A1=nvm_data_107 S0=nx37166
Xix11637 mux21_ni $PINS Y=nx11636 A0=nx11632 A1=nx11620 S0=nx37102
Xix11621 mux21_ni $PINS Y=nx11620 A0=nvm_data_83 A1=nvm_data_91 S0=nx37166
Xix11633 mux21_ni $PINS Y=nx11632 A0=nvm_data_67 A1=nvm_data_75 S0=nx37168
Xix11583 mux21_ni $PINS Y=nx11582 A0=nx11550 A1=nx11576 S0=nx37110
Xix11577 mux21_ni $PINS Y=nx11576 A0=nx11572 A1=nx11560 S0=nx37102
Xix11561 mux21_ni $PINS Y=nx11560 A0=nvm_data_51 A1=nvm_data_59 S0=nx37168
Xix11573 mux21_ni $PINS Y=nx11572 A0=nvm_data_35 A1=nvm_data_43 S0=nx37168
Xix30008 mux21 $PINS Y=nx30007 A0=nvm_data_19 A1=nvm_data_27 S0=nx37168
Xix31102 xor2 $PINS Y=nx31101 A0=nx32240 A1=nx31106
Xix19835 mux21 $PINS Y=nx19834 A0=nx35676 A1=nx31106 S0=nx37140
Xix31120 mux21 $PINS Y=nx31119 A0=nx17184 A1=nx17156 S0=nx37110
Xix17157 mux21_ni $PINS Y=nx17156 A0=nx17152 A1=nx17140 S0=nx37102
Xix17141 mux21_ni $PINS Y=nx17140 A0=nvm_data_117 A1=nvm_data_125 S0=nx37168
Xix17153 mux21_ni $PINS Y=nx17152 A0=nvm_data_101 A1=nvm_data_109 S0=nx37168
Xix17185 mux21_ni $PINS Y=nx17184 A0=nx17180 A1=nx17168 S0=nx37104
Xix17169 mux21_ni $PINS Y=nx17168 A0=nvm_data_85 A1=nvm_data_93 S0=nx37168
Xix17181 mux21_ni $PINS Y=nx17180 A0=nvm_data_69 A1=nvm_data_77 S0=nx37170
Xix17131 mux21_ni $PINS Y=nx17130 A0=nx17098 A1=nx17124 S0=nx37110
Xix17125 mux21_ni $PINS Y=nx17124 A0=nx17120 A1=nx17108 S0=nx37104
Xix17109 mux21_ni $PINS Y=nx17108 A0=nvm_data_53 A1=nvm_data_61 S0=nx37170
Xix17121 mux21_ni $PINS Y=nx17120 A0=nvm_data_37 A1=nvm_data_45 S0=nx37170
Xix31150 mux21 $PINS Y=nx31149 A0=nvm_data_21 A1=nvm_data_29 S0=nx37170
Xix32244 xor2 $PINS Y=nx32243 A0=nx33382 A1=nx32248
Xix25383 mux21 $PINS Y=nx25382 A0=nx35678 A1=nx32248 S0=nx37140
Xix32262 mux21 $PINS Y=nx32261 A0=nx22732 A1=nx22704 S0=nx37110
Xix22705 mux21_ni $PINS Y=nx22704 A0=nx22700 A1=nx22688 S0=nx37104
Xix22689 mux21_ni $PINS Y=nx22688 A0=nvm_data_119 A1=nvm_data_127 S0=nx37170
Xix22701 mux21_ni $PINS Y=nx22700 A0=nvm_data_103 A1=nvm_data_111 S0=nx37170
Xix22733 mux21_ni $PINS Y=nx22732 A0=nx22728 A1=nx22716 S0=nx37104
Xix22717 mux21_ni $PINS Y=nx22716 A0=nvm_data_87 A1=nvm_data_95 S0=nx37170
Xix22729 mux21_ni $PINS Y=nx22728 A0=nvm_data_71 A1=nvm_data_79 S0=nx35720
Xix22679 mux21_ni $PINS Y=nx22678 A0=nx22646 A1=nx22672 S0=nx37110
Xix22673 mux21_ni $PINS Y=nx22672 A0=nx22668 A1=nx22656 S0=nx37104
Xix22657 mux21_ni $PINS Y=nx22656 A0=nvm_data_55 A1=nvm_data_63 S0=nx35720
Xix22669 mux21_ni $PINS Y=nx22668 A0=nvm_data_39 A1=nvm_data_47 S0=nx35720
Xix32292 mux21 $PINS Y=nx32291 A0=nvm_data_23 A1=nvm_data_31 S0=nx35720
Xix26027 xor2 $PINS Y=nx26026 A0=nx25398 A1=nx37086
Xix33461 xor2 $PINS Y=nx33460 A0=nx22689 A1=nx37086
Xix26175 xor2 $PINS Y=nx26174 A0=nx25406 A1=nx37088
Xix33468 xor2 $PINS Y=nx33467 A0=nx22685 A1=nx37088
Xix26323 xor2 $PINS Y=nx26322 A0=nx25414 A1=nx37088
Xix33475 xor2 $PINS Y=nx33474 A0=nx22681 A1=nx37088
Xix693 nor03_2x $PINS Y=nx34150 A0=nx37084 A1=nx37416 A2=nx686
Xix22204 mux21_ni $PINS Y=nx22203
+ A0=camera_module_algo_module_current_cont_value_13 A1=nx26380 S0=nx37306
Xix26381 mux21_ni $PINS Y=nx26380 A0=camera_module_algo_module_Addout_value_13
+ A1=zero S0=nx37074
Xix22194 mux21_ni $PINS Y=nx22193 A0=nx26366
+ A1=camera_module_algo_module_Addout_value_13 S0=nx37118
Xix26367 mux21_ni $PINS Y=nx26366 A0=zero A1=nx26358 S0=nx37140
Xix22154 mux21 $PINS Y=nx22153 A0=nx33491 A1=nx33489 S0=nx37130
Xix22144 mux21_ni $PINS Y=nx22143
+ A0=camera_module_algo_module_current_cont_value_11 A1=nx26232 S0=nx37306
Xix26233 mux21_ni $PINS Y=nx26232 A0=camera_module_algo_module_Addout_value_11
+ A1=zero S0=nx37074
Xix22134 mux21_ni $PINS Y=nx22133 A0=nx26218
+ A1=camera_module_algo_module_Addout_value_11 S0=nx37118
Xix26219 mux21_ni $PINS Y=nx26218 A0=zero A1=nx26210 S0=nx37140
Xix22094 mux21 $PINS Y=nx22093 A0=nx33510 A1=nx33508 S0=nx37130
Xix22084 mux21_ni $PINS Y=nx22083
+ A0=camera_module_algo_module_current_cont_value_9 A1=nx26084 S0=nx37306
Xix26085 mux21_ni $PINS Y=nx26084 A0=camera_module_algo_module_Addout_value_9
+ A1=zero S0=nx37074
Xix22074 mux21_ni $PINS Y=nx22073 A0=nx26070
+ A1=camera_module_algo_module_Addout_value_9 S0=nx37118
Xix26071 mux21_ni $PINS Y=nx26070 A0=zero A1=nx26062 S0=nx37140
Xix22034 mux21_ni $PINS Y=nx22033 A0=nx25972
+ A1=camera_module_algo_module_diff_value_7 S0=nx37130
Xix25973 mux21_ni $PINS Y=nx25972 A0=zero A1=nx25964 S0=nx37140
Xix25965 mux21 $PINS Y=nx25964 A0=nx33453 A1=nx33529 S0=nx37090
Xix22024 mux21_ni $PINS Y=nx22023
+ A0=camera_module_algo_module_current_cont_value_7 A1=nx25936 S0=nx37306
Xix25937 mux21_ni $PINS Y=nx25936 A0=camera_module_algo_module_Addout_value_7
+ A1=zero S0=nx37074
Xix22014 mux21_ni $PINS Y=nx22013 A0=nx25922
+ A1=camera_module_algo_module_Addout_value_7 S0=nx37118
Xix25923 mux21_ni $PINS Y=nx25922 A0=zero A1=nx25914 S0=nx37140
Xix21974 mux21_ni $PINS Y=nx21973 A0=nx25824
+ A1=camera_module_algo_module_diff_value_5 S0=nx37130
Xix25825 mux21_ni $PINS Y=nx25824 A0=zero A1=nx25816 S0=nx37142
Xix25817 mux21 $PINS Y=nx25816 A0=nx33446 A1=nx33546 S0=nx37090
Xix21964 mux21_ni $PINS Y=nx21963
+ A0=camera_module_algo_module_current_cont_value_5 A1=nx25788 S0=nx37306
Xix25789 mux21_ni $PINS Y=nx25788 A0=camera_module_algo_module_Addout_value_5
+ A1=zero S0=nx37370
Xix21954 mux21_ni $PINS Y=nx21953 A0=nx25774
+ A1=camera_module_algo_module_Addout_value_5 S0=nx37118
Xix25775 mux21_ni $PINS Y=nx25774 A0=zero A1=nx25766 S0=nx37142
Xix21914 mux21_ni $PINS Y=nx21913 A0=nx25676
+ A1=camera_module_algo_module_diff_value_3 S0=nx37130
Xix25677 mux21_ni $PINS Y=nx25676 A0=zero A1=nx25668 S0=nx37142
Xix25669 mux21 $PINS Y=nx25668 A0=nx33439 A1=nx33563 S0=nx37090
Xix21904 mux21_ni $PINS Y=nx21903
+ A0=camera_module_algo_module_current_cont_value_3 A1=nx25640 S0=nx37306
Xix25641 mux21_ni $PINS Y=nx25640 A0=camera_module_algo_module_Addout_value_3
+ A1=zero S0=nx37370
Xix21894 mux21_ni $PINS Y=nx21893 A0=nx25626
+ A1=camera_module_algo_module_Addout_value_3 S0=nx37120
Xix25627 mux21_ni $PINS Y=nx25626 A0=zero A1=nx25618 S0=nx37142
Xix21854 mux21_ni $PINS Y=nx21853 A0=nx25528
+ A1=camera_module_algo_module_diff_value_1 S0=nx37130
Xix25529 mux21_ni $PINS Y=nx25528 A0=zero A1=nx25520 S0=nx37142
Xix25521 mux21 $PINS Y=nx25520 A0=nx33429 A1=nx33580 S0=nx37090
Xix21844 mux21_ni $PINS Y=nx21843
+ A0=camera_module_algo_module_current_cont_value_1 A1=nx25492 S0=nx37308
Xix25493 mux21_ni $PINS Y=nx25492 A0=camera_module_algo_module_Addout_value_1
+ A1=zero S0=nx37370
Xix21834 mux21_ni $PINS Y=nx21833 A0=nx25478
+ A1=camera_module_algo_module_Addout_value_1 S0=nx37120
Xix25479 mux21_ni $PINS Y=nx25478 A0=zero A1=nx25470 S0=nx37142
Xix33592 xnor2 $PINS Y=nx33591 A0=nx33609 A1=nx33615
Xix1244 mux21_ni $PINS Y=nx1243
+ A0=camera_module_algo_module_current_cont_value_0 A1=nx678 S0=nx37308
Xix679 mux21_ni $PINS Y=nx678 A0=camera_module_algo_module_Addout_value_0
+ A1=zero S0=nx37372
Xix1234 mux21_ni $PINS Y=nx1233 A0=nx664
+ A1=camera_module_algo_module_Addout_value_0 S0=nx37120
Xix665 mux21_ni $PINS Y=nx664 A0=zero A1=nx656 S0=nx37142
Xix655 nor03_2x $PINS Y=nx34007 A0=nx37416
+ A1=camera_module_algo_module_modCU_current_state_5 A2=nx37070
Xix33602 nand03 $PINS Y=nx37070 A0=nx22993 A1=nx22979 A2=nx37072
Xix37071 inv01 $PINS Y=nx37072
+ A=camera_module_algo_module_modCU_current_state_7
Xix33605 nand04 $PINS Y=nx36796 A0=nx37406 A1=nx37094 A2=nx22987 A3=nx33608
Xix21824 mux21_ni $PINS Y=nx21823 A0=nx25454
+ A1=camera_module_algo_module_diff_value_0 S0=nx37132
Xix25455 mux21_ni $PINS Y=nx25454 A0=zero A1=nx25446 S0=nx37144
Xix25447 mux21_ni $PINS Y=nx25446 A0=nx25434 A1=nx25438 S0=nx37092
Xix33617 xor2 $PINS Y=nx33616 A0=nx33619
+ A1=camera_module_algo_module_diff_value_1
Xix33622 xnor2 $PINS Y=nx33621 A0=nx33632 A1=nx33638
Xix21874 mux21_ni $PINS Y=nx21873
+ A0=camera_module_algo_module_current_cont_value_2 A1=nx25566 S0=nx37308
Xix25567 mux21_ni $PINS Y=nx25566 A0=camera_module_algo_module_Addout_value_2
+ A1=zero S0=nx37372
Xix21864 mux21_ni $PINS Y=nx21863 A0=nx25552
+ A1=camera_module_algo_module_Addout_value_2 S0=nx37120
Xix25553 mux21 $PINS Y=nx25552 A0=nx35680 A1=nx33629 S0=nx37144
Xix21884 mux21_ni $PINS Y=nx21883 A0=nx25602
+ A1=camera_module_algo_module_diff_value_2 S0=nx37132
Xix25603 mux21_ni $PINS Y=nx25602 A0=zero A1=nx25594 S0=nx37144
Xix25595 mux21_ni $PINS Y=nx25594 A0=nx25582 A1=nx25586 S0=nx37092
Xix33640 xor2 $PINS Y=nx33639 A0=nx33642
+ A1=camera_module_algo_module_diff_value_3
Xix33645 xnor2 $PINS Y=nx33644 A0=nx33655 A1=nx33661
Xix21934 mux21_ni $PINS Y=nx21933
+ A0=camera_module_algo_module_current_cont_value_4 A1=nx25714 S0=nx37308
Xix25715 mux21_ni $PINS Y=nx25714 A0=camera_module_algo_module_Addout_value_4
+ A1=zero S0=nx37372
Xix21924 mux21_ni $PINS Y=nx21923 A0=nx25700
+ A1=camera_module_algo_module_Addout_value_4 S0=nx37120
Xix25701 mux21 $PINS Y=nx25700 A0=nx35680 A1=nx33652 S0=nx37144
Xix21944 mux21_ni $PINS Y=nx21943 A0=nx25750
+ A1=camera_module_algo_module_diff_value_4 S0=nx37132
Xix25751 mux21_ni $PINS Y=nx25750 A0=zero A1=nx25742 S0=nx37144
Xix25743 mux21_ni $PINS Y=nx25742 A0=nx25730 A1=nx25734 S0=nx37092
Xix33663 xor2 $PINS Y=nx33662 A0=nx33665
+ A1=camera_module_algo_module_diff_value_5
Xix33668 xnor2 $PINS Y=nx33667 A0=nx33678 A1=nx33684
Xix21994 mux21_ni $PINS Y=nx21993
+ A0=camera_module_algo_module_current_cont_value_6 A1=nx25862 S0=nx37308
Xix25863 mux21_ni $PINS Y=nx25862 A0=camera_module_algo_module_Addout_value_6
+ A1=zero S0=nx37372
Xix21984 mux21_ni $PINS Y=nx21983 A0=nx25848
+ A1=camera_module_algo_module_Addout_value_6 S0=nx37120
Xix25849 mux21 $PINS Y=nx25848 A0=nx35680 A1=nx33675 S0=nx37144
Xix22004 mux21_ni $PINS Y=nx22003 A0=nx25898
+ A1=camera_module_algo_module_diff_value_6 S0=nx37132
Xix25899 mux21_ni $PINS Y=nx25898 A0=zero A1=nx25890 S0=nx37144
Xix25891 mux21_ni $PINS Y=nx25890 A0=nx25878 A1=nx25882 S0=nx37092
Xix33686 xor2 $PINS Y=nx33685 A0=nx33688
+ A1=camera_module_algo_module_diff_value_7
Xix33691 xnor2 $PINS Y=nx33690 A0=nx33701 A1=nx33707
Xix22054 mux21_ni $PINS Y=nx22053
+ A0=camera_module_algo_module_current_cont_value_8 A1=nx26010 S0=nx37308
Xix26011 mux21_ni $PINS Y=nx26010 A0=camera_module_algo_module_Addout_value_8
+ A1=zero S0=nx37074
Xix22044 mux21_ni $PINS Y=nx22043 A0=nx25996
+ A1=camera_module_algo_module_Addout_value_8 S0=nx37120
Xix25997 mux21 $PINS Y=nx25996 A0=nx35680 A1=nx33698 S0=nx35688
Xix22064 mux21_ni $PINS Y=nx22063 A0=nx26046
+ A1=camera_module_algo_module_diff_value_8 S0=nx37132
Xix26047 mux21_ni $PINS Y=nx26046 A0=zero A1=nx26038 S0=nx35688
Xix26039 mux21_ni $PINS Y=nx26038 A0=nx26026 A1=nx26030 S0=nx37092
Xix33709 xnor2 $PINS Y=nx33708 A0=nx33711 A1=nx33508
Xix33714 xnor2 $PINS Y=nx33713 A0=nx33724 A1=nx33727
Xix22114 mux21_ni $PINS Y=nx22113
+ A0=camera_module_algo_module_current_cont_value_10 A1=nx26158 S0=nx37308
Xix26159 mux21_ni $PINS Y=nx26158 A0=camera_module_algo_module_Addout_value_10
+ A1=zero S0=nx37076
Xix22104 mux21_ni $PINS Y=nx22103 A0=nx26144
+ A1=camera_module_algo_module_Addout_value_10 S0=nx37122
Xix26145 mux21 $PINS Y=nx26144 A0=nx35680 A1=nx33721 S0=nx35688
Xix22124 mux21 $PINS Y=nx22123 A0=nx33729 A1=nx33727 S0=nx37132
Xix33735 xnor2 $PINS Y=nx33734 A0=nx33737 A1=nx33489
Xix33740 xnor2 $PINS Y=nx33739 A0=nx33750 A1=nx33753
Xix22174 mux21_ni $PINS Y=nx22173
+ A0=camera_module_algo_module_current_cont_value_12 A1=nx26306 S0=nx37310
Xix26307 mux21_ni $PINS Y=nx26306 A0=camera_module_algo_module_Addout_value_12
+ A1=zero S0=nx37076
Xix22164 mux21_ni $PINS Y=nx22163 A0=nx26292
+ A1=camera_module_algo_module_Addout_value_12 S0=nx37122
Xix26293 mux21 $PINS Y=nx26292 A0=nx35682 A1=nx33747 S0=nx35688
Xix22184 mux21 $PINS Y=nx22183 A0=nx33755 A1=nx33753 S0=nx37132
Xix33761 xnor2 $PINS Y=nx33760 A0=nx33763 A1=nx22651
Xix33766 xnor2 $PINS Y=nx33765 A0=nx33776 A1=nx33779
Xix22234 mux21_ni $PINS Y=nx22233
+ A0=camera_module_algo_module_current_cont_value_14 A1=nx26454 S0=nx37310
Xix26455 mux21_ni $PINS Y=nx26454 A0=camera_module_algo_module_Addout_value_14
+ A1=zero S0=nx37076
Xix22224 mux21_ni $PINS Y=nx22223 A0=nx26440
+ A1=camera_module_algo_module_Addout_value_14 S0=nx37122
Xix26441 mux21 $PINS Y=nx26440 A0=nx35682 A1=nx33773 S0=nx37146
Xix22244 mux21 $PINS Y=nx22243 A0=nx33781 A1=nx33779 S0=nx37134
Xix26471 xor2 $PINS Y=nx26470 A0=nx25422 A1=nx37088
Xix33791 xnor2 $PINS Y=nx33790 A0=nx33810 A1=nx33794
Xix22254 mux21 $PINS Y=nx22253 A0=nx33796 A1=nx33794 S0=nx37134
Xix33808 xor2 $PINS Y=nx33807 A0=nx22669 A1=nx37088
Xix22284 mux21_ni $PINS Y=nx22283
+ A0=camera_module_algo_module_prev_cont_value_15 A1=nx26580 S0=nx37076
Xix26581 mux21_ni $PINS Y=nx26580 A0=zero
+ A1=camera_module_algo_module_current_cont_value_15 S0=nx37146
Xix22294 mux21_ni $PINS Y=nx22293
+ A0=camera_module_algo_module_prev_cont_value_14 A1=nx26596 S0=nx37076
Xix26597 mux21_ni $PINS Y=nx26596 A0=zero
+ A1=camera_module_algo_module_current_cont_value_14 S0=nx37146
Xix26605 xnor2 $PINS Y=nx26604 A0=nx33776 A1=nx33818
Xix33826 xnor2 $PINS Y=nx33825 A0=nx33763
+ A1=camera_module_algo_module_prev_cont_value_13
Xix22304 mux21_ni $PINS Y=nx22303
+ A0=camera_module_algo_module_prev_cont_value_13 A1=nx26612 S0=nx37076
Xix26613 mux21_ni $PINS Y=nx26612 A0=zero
+ A1=camera_module_algo_module_current_cont_value_13 S0=nx37148
Xix22314 mux21_ni $PINS Y=nx22313
+ A0=camera_module_algo_module_prev_cont_value_12 A1=nx26628 S0=nx37076
Xix26629 mux21_ni $PINS Y=nx26628 A0=zero
+ A1=camera_module_algo_module_current_cont_value_12 S0=nx37148
Xix26637 xnor2 $PINS Y=nx26636 A0=nx33750 A1=nx33834
Xix33842 xnor2 $PINS Y=nx33841 A0=nx33737
+ A1=camera_module_algo_module_prev_cont_value_11
Xix22324 mux21_ni $PINS Y=nx22323
+ A0=camera_module_algo_module_prev_cont_value_11 A1=nx26644 S0=nx37078
Xix26645 mux21_ni $PINS Y=nx26644 A0=zero
+ A1=camera_module_algo_module_current_cont_value_11 S0=nx37148
Xix22334 mux21_ni $PINS Y=nx22333
+ A0=camera_module_algo_module_prev_cont_value_10 A1=nx26660 S0=nx37078
Xix26661 mux21_ni $PINS Y=nx26660 A0=zero
+ A1=camera_module_algo_module_current_cont_value_10 S0=nx37148
Xix26669 xnor2 $PINS Y=nx26668 A0=nx33724 A1=nx33850
Xix33858 xnor2 $PINS Y=nx33857 A0=nx33711
+ A1=camera_module_algo_module_prev_cont_value_9
Xix22344 mux21_ni $PINS Y=nx22343
+ A0=camera_module_algo_module_prev_cont_value_9 A1=nx26676 S0=nx37078
Xix26677 mux21_ni $PINS Y=nx26676 A0=zero
+ A1=camera_module_algo_module_current_cont_value_9 S0=nx37148
Xix22354 mux21_ni $PINS Y=nx22353
+ A0=camera_module_algo_module_prev_cont_value_8 A1=nx26692 S0=nx37078
Xix26693 mux21_ni $PINS Y=nx26692 A0=zero
+ A1=camera_module_algo_module_current_cont_value_8 S0=nx37148
Xix26701 xnor2 $PINS Y=nx26700 A0=nx33701 A1=nx33866
Xix33874 xnor2 $PINS Y=nx33873 A0=nx33688
+ A1=camera_module_algo_module_prev_cont_value_7
Xix22364 mux21_ni $PINS Y=nx22363
+ A0=camera_module_algo_module_prev_cont_value_7 A1=nx26708 S0=nx37078
Xix26709 mux21_ni $PINS Y=nx26708 A0=zero
+ A1=camera_module_algo_module_current_cont_value_7 S0=nx37148
Xix22374 mux21_ni $PINS Y=nx22373
+ A0=camera_module_algo_module_prev_cont_value_6 A1=nx26724 S0=nx37078
Xix26725 mux21_ni $PINS Y=nx26724 A0=zero
+ A1=camera_module_algo_module_current_cont_value_6 S0=nx37150
Xix26733 xnor2 $PINS Y=nx26732 A0=nx33678 A1=nx33882
Xix33890 xnor2 $PINS Y=nx33889 A0=nx33665
+ A1=camera_module_algo_module_prev_cont_value_5
Xix22384 mux21_ni $PINS Y=nx22383
+ A0=camera_module_algo_module_prev_cont_value_5 A1=nx26740 S0=nx37078
Xix26741 mux21_ni $PINS Y=nx26740 A0=zero
+ A1=camera_module_algo_module_current_cont_value_5 S0=nx37150
Xix22394 mux21_ni $PINS Y=nx22393
+ A0=camera_module_algo_module_prev_cont_value_4 A1=nx26756 S0=nx37080
Xix26757 mux21_ni $PINS Y=nx26756 A0=zero
+ A1=camera_module_algo_module_current_cont_value_4 S0=nx37150
Xix26765 xnor2 $PINS Y=nx26764 A0=nx33655 A1=nx33898
Xix33906 xnor2 $PINS Y=nx33905 A0=nx33642
+ A1=camera_module_algo_module_prev_cont_value_3
Xix22404 mux21_ni $PINS Y=nx22403
+ A0=camera_module_algo_module_prev_cont_value_3 A1=nx26772 S0=nx37080
Xix26773 mux21_ni $PINS Y=nx26772 A0=zero
+ A1=camera_module_algo_module_current_cont_value_3 S0=nx37150
Xix22414 mux21_ni $PINS Y=nx22413
+ A0=camera_module_algo_module_prev_cont_value_2 A1=nx26788 S0=nx37080
Xix26789 mux21_ni $PINS Y=nx26788 A0=zero
+ A1=camera_module_algo_module_current_cont_value_2 S0=nx37150
Xix26797 xnor2 $PINS Y=nx26796 A0=nx33632 A1=nx33914
Xix33922 xnor2 $PINS Y=nx33921 A0=nx33619
+ A1=camera_module_algo_module_prev_cont_value_1
Xix22424 mux21_ni $PINS Y=nx22423
+ A0=camera_module_algo_module_prev_cont_value_1 A1=nx26804 S0=nx37080
Xix26805 mux21_ni $PINS Y=nx26804 A0=zero
+ A1=camera_module_algo_module_current_cont_value_1 S0=nx37150
Xix22434 mux21_ni $PINS Y=nx22433
+ A0=camera_module_algo_module_prev_cont_value_0 A1=nx26820 S0=nx37080
Xix26821 mux21_ni $PINS Y=nx26820 A0=zero
+ A1=camera_module_algo_module_current_cont_value_0 S0=nx37150
Xix26829 xnor2 $PINS Y=nx26828 A0=nx33609 A1=nx33930
Xix22464 mux21_ni $PINS Y=nx22463
+ A0=camera_module_algo_module_current_cont_value_16 A1=nx27016 S0=nx37310
Xix27017 mux21_ni $PINS Y=nx27016 A0=camera_module_algo_module_Addout_value_16
+ A1=zero S0=nx37080
Xix22454 mux21_ni $PINS Y=nx22453 A0=nx27002
+ A1=camera_module_algo_module_Addout_value_16 S0=nx37122
Xix27003 mux21 $PINS Y=nx27002 A0=nx35682 A1=nx33943 S0=nx35690
Xix22444 mux21_ni $PINS Y=nx22443 A0=nx26984
+ A1=camera_module_algo_module_diff_value_16 S0=nx37134
Xix33959 xor2 $PINS Y=nx33958 A0=zero A1=nx37092
Xix33962 nor02ii $PINS Y=nx33961 A0=camera_module_algo_module_pixel_value_8
+ A1=zero
Xix22474 mux21_ni $PINS Y=nx22473
+ A0=camera_module_algo_module_prev_cont_value_16 A1=nx27030 S0=nx37080
Xix27031 mux21_ni $PINS Y=nx27030 A0=zero
+ A1=camera_module_algo_module_current_cont_value_16 S0=nx35690
Xix34004 or02 $PINS Y=nx34003 A0=rst A1=nx22601
Xix34026 or02 $PINS Y=nx20 A0=camera_module_ack_from_DMA A1=rst
Xix35705 and02 $PINS Y=nx35706 A0=nx35688 A1=nx22601
Xix35715 and02 $PINS Y=nx35716 A0=nx37126 A1=nx37176
Xix35797 and02 $PINS Y=nx35798 A0=nx37406 A1=nx22979
Xix37073 inv02 $PINS Y=nx37074 A=nx37406
Xix37075 inv02 $PINS Y=nx37076 A=nx37406
Xix37077 inv02 $PINS Y=nx37078 A=nx37406
Xix37079 inv02 $PINS Y=nx37080 A=nx37114
Xix37081 buf02 $PINS Y=nx37082 A=nx688
Xix37083 buf02 $PINS Y=nx37084 A=nx688
Xix37085 inv02 $PINS Y=nx37086 A=nx22677
Xix37087 inv02 $PINS Y=nx37088 A=nx22677
Xix37089 inv02 $PINS Y=nx37090 A=nx35700
Xix37091 inv02 $PINS Y=nx37092 A=nx35700
Xix37093 inv02 $PINS Y=nx37094 A=nx408
Xix37095 inv02 $PINS Y=nx37096 A=nx34098
Xix37097 inv02 $PINS Y=nx37098 A=nx34098
Xix37099 inv02 $PINS Y=nx37100 A=nx34098
Xix37101 inv02 $PINS Y=nx37102 A=nx34098
Xix37103 inv02 $PINS Y=nx37104 A=nx34098
Xix37105 inv02 $PINS Y=nx37106 A=nx34112
Xix37107 inv02 $PINS Y=nx37108 A=nx34112
Xix37109 inv02 $PINS Y=nx37110 A=nx34112
Xix37111 inv02 $PINS Y=nx37112 A=nx404
Xix37113 inv02 $PINS Y=nx37114 A=nx404
Xix37115 inv01 $PINS Y=nx37116 A=nx34007
Xix37117 inv02 $PINS Y=nx37118 A=nx37116
Xix37119 inv02 $PINS Y=nx37120 A=nx37116
Xix37121 inv02 $PINS Y=nx37122 A=nx37116
Xix37123 inv02 $PINS Y=nx37124 A=camera_module_DMA_module_signals_1
Xix37125 inv02 $PINS Y=nx37126 A=camera_module_DMA_module_signals_1
Xix37127 inv01 $PINS Y=nx37128 A=nx34150
Xix37129 inv02 $PINS Y=nx37130 A=nx37128
Xix37131 inv02 $PINS Y=nx37132 A=nx37128
Xix37133 inv02 $PINS Y=nx37134 A=nx37128
Xix37135 inv02 $PINS Y=nx37136 A=nx37416
Xix37137 inv02 $PINS Y=nx37138 A=nx37416
Xix37139 inv02 $PINS Y=nx37140 A=nx37418
Xix37141 inv02 $PINS Y=nx37142 A=nx37418
Xix37143 inv02 $PINS Y=nx37144 A=nx37418
Xix37145 inv02 $PINS Y=nx37146 A=nx37418
Xix37147 inv02 $PINS Y=nx37148 A=nx37418
Xix37149 inv02 $PINS Y=nx37150 A=nx37418
Xix37151 buf02 $PINS Y=nx37152 A=nx35706
Xix37153 buf02 $PINS Y=nx37154 A=nx35716
Xix37155 inv02 $PINS Y=nx37156 A=nx37412
Xix37157 inv02 $PINS Y=nx37158 A=nx37412
Xix37159 inv02 $PINS Y=nx37160 A=nx37412
Xix37161 inv02 $PINS Y=nx37162 A=nx37412
Xix37163 inv02 $PINS Y=nx37164 A=nx37412
Xix37165 inv02 $PINS Y=nx37166 A=nx37414
Xix37167 inv02 $PINS Y=nx37168 A=nx37414
Xix37169 inv02 $PINS Y=nx37170 A=nx37414
Xix37171 inv02 $PINS Y=nx37172 A=nx37364
Xix37173 inv02 $PINS Y=nx37174 A=nx37366
Xix37175 inv02 $PINS Y=nx37176 A=nx37366
Xix37177 inv02 $PINS Y=nx37178 A=nx37366
Xix37179 inv02 $PINS Y=nx37180 A=nx37366
Xix37181 inv02 $PINS Y=nx37182 A=nx37366
Xix37183 inv02 $PINS Y=nx37184 A=nx37366
Xix37185 inv02 $PINS Y=nx37186 A=nx37366
Xix37187 inv02 $PINS Y=nx37188 A=nx37368
Xix37189 inv02 $PINS Y=nx37190 A=nx37368
Xix37191 inv02 $PINS Y=nx37192 A=nx36912
Xix37193 inv02 $PINS Y=nx37194 A=nx36912
Xix37195 inv02 $PINS Y=nx37196 A=nx436
Xix37197 buf02 $PINS Y=nx37198 A=nx35798
Xix37199 inv02 $PINS Y=nx37200 A=nx37012
Xix37201 inv02 $PINS Y=nx37202 A=nx37006
Xix37203 inv02 $PINS Y=nx37204 A=nx37000
Xix37205 inv02 $PINS Y=nx37206 A=nx36994
Xix37207 inv02 $PINS Y=nx37208 A=nx36988
Xix37209 inv02 $PINS Y=nx37210 A=nx36982
Xix37211 inv02 $PINS Y=nx37212 A=nx36970
Xix37213 inv02 $PINS Y=nx37214 A=nx36976
Xix37215 inv02 $PINS Y=nx37216 A=nx36964
Xix37217 inv02 $PINS Y=nx37218 A=nx36958
Xix37219 inv02 $PINS Y=nx37220 A=nx36946
Xix37221 inv02 $PINS Y=nx37222 A=nx36952
Xix37223 inv02 $PINS Y=nx37224 A=nx36940
Xix37225 inv02 $PINS Y=nx37226 A=nx36934
Xix37227 inv02 $PINS Y=nx37228 A=nx36928
Xix37229 inv02 $PINS Y=nx37230 A=nx36920
Xix37231 inv02 $PINS Y=nx37232 A=nx5650
Xix37233 inv02 $PINS Y=nx37234 A=nx5650
Xix37235 inv02 $PINS Y=nx37236 A=nx5358
Xix37237 inv02 $PINS Y=nx37238 A=nx5358
Xix37239 inv02 $PINS Y=nx37240 A=nx5064
Xix37241 inv02 $PINS Y=nx37242 A=nx5064
Xix37243 inv02 $PINS Y=nx37244 A=nx4772
Xix37245 inv02 $PINS Y=nx37246 A=nx4772
Xix37247 inv02 $PINS Y=nx37248 A=nx4474
Xix37249 inv02 $PINS Y=nx37250 A=nx4474
Xix37251 inv02 $PINS Y=nx37252 A=nx4182
Xix37253 inv02 $PINS Y=nx37254 A=nx4182
Xix37255 inv02 $PINS Y=nx37256 A=nx3888
Xix37257 inv02 $PINS Y=nx37258 A=nx3888
Xix37259 inv02 $PINS Y=nx37260 A=nx3596
Xix37261 inv02 $PINS Y=nx37262 A=nx3596
Xix37263 inv02 $PINS Y=nx37264 A=nx3294
Xix37265 inv02 $PINS Y=nx37266 A=nx3294
Xix37267 inv02 $PINS Y=nx37268 A=nx3002
Xix37269 inv02 $PINS Y=nx37270 A=nx3002
Xix37271 inv02 $PINS Y=nx37272 A=nx2708
Xix37273 inv02 $PINS Y=nx37274 A=nx2708
Xix37275 inv02 $PINS Y=nx37276 A=nx2416
Xix37277 inv02 $PINS Y=nx37278 A=nx2416
Xix37279 inv02 $PINS Y=nx37280 A=nx36506
Xix37281 inv02 $PINS Y=nx37282 A=nx36506
Xix37283 inv02 $PINS Y=nx37284 A=nx36506
Xix37285 inv02 $PINS Y=nx37286 A=nx36580
Xix37287 inv02 $PINS Y=nx37288 A=nx36580
Xix37289 inv02 $PINS Y=nx37290 A=nx36580
Xix37291 inv02 $PINS Y=nx37292 A=nx36654
Xix37293 inv02 $PINS Y=nx37294 A=nx36654
Xix37295 inv02 $PINS Y=nx37296 A=nx36654
Xix37297 inv02 $PINS Y=nx37298 A=nx24811
Xix37299 inv02 $PINS Y=nx37300 A=nx24811
Xix37301 inv02 $PINS Y=nx37302 A=nx24811
Xix37303 inv01 $PINS Y=nx37304 A=nx36796
Xix37305 inv02 $PINS Y=nx37306 A=nx37304
Xix37307 inv02 $PINS Y=nx37308 A=nx37304
Xix37309 inv02 $PINS Y=nx37310 A=nx37304
Xix37311 inv02 $PINS Y=nx37312 A=nx37422
Xix37313 inv02 $PINS Y=nx37314 A=nx37422
Xix37315 inv02 $PINS Y=nx37316 A=nx37422
Xix37317 inv02 $PINS Y=nx37318 A=nx37422
Xix37319 inv02 $PINS Y=nx37320 A=nx37422
Xix37321 inv02 $PINS Y=nx37322 A=nx37422
Xix37323 inv02 $PINS Y=nx37324 A=nx37424
Xix37325 inv02 $PINS Y=nx37326 A=nx37424
Xix37327 inv02 $PINS Y=nx37328 A=nx37424
Xix37329 inv02 $PINS Y=nx37330 A=nx37424
Xix37331 inv02 $PINS Y=nx37332 A=nx37424
Xix37333 inv02 $PINS Y=nx37334 A=nx37424
Xix37335 inv02 $PINS Y=nx37336 A=nx37424
Xix37337 inv02 $PINS Y=nx37338 A=nx37426
Xix37339 inv02 $PINS Y=nx37340 A=nx37426
Xix37341 inv02 $PINS Y=nx37342 A=nx37426
Xix37343 inv02 $PINS Y=nx37344 A=nx37426
Xix37345 inv02 $PINS Y=nx37346 A=nx37426
Xix37347 inv02 $PINS Y=nx37348 A=nx37426
Xix37349 inv02 $PINS Y=nx37350 A=nx37426
Xix37351 inv02 $PINS Y=nx37352 A=nx37428
Xix37353 inv02 $PINS Y=nx37354 A=nx37428
Xix37355 inv02 $PINS Y=nx37356 A=nx37428
Xix37357 inv02 $PINS Y=nx37358 A=nx37428
Xix37359 inv02 $PINS Y=nx37360 A=nx37428
Xix37361 inv02 $PINS Y=nx37362 A=nx37428
Xix37363 inv02 $PINS Y=nx37364 A=nx37428
Xix37365 inv02 $PINS Y=nx37366 A=nx37430
Xix37367 inv02 $PINS Y=nx37368 A=nx37430
Xix37369 inv02 $PINS Y=nx37370 A=nx37112
Xix37371 inv02 $PINS Y=nx37372 A=nx37112
Xix37373 inv02 $PINS Y=nx37374 A=nx23298
Xix37375 inv02 $PINS Y=nx37376 A=nx23290
Xix37377 inv02 $PINS Y=nx37378 A=nx23279
Xix37379 inv02 $PINS Y=nx37380 A=nx23267
Xix37381 inv02 $PINS Y=nx37382 A=nx36208
Xix37383 inv02 $PINS Y=nx37384 A=nx36248
Xix37385 inv02 $PINS Y=nx37386 A=nx36168
Xix37387 inv02 $PINS Y=nx37388 A=nx36128
Xix37389 inv02 $PINS Y=nx37390 A=nx36048
Xix37391 inv02 $PINS Y=nx37392 A=nx36088
Xix37393 inv02 $PINS Y=nx37394 A=nx36008
Xix37395 inv02 $PINS Y=nx37396 A=nx35968
Xix37397 inv02 $PINS Y=nx37398 A=nx35928
Xix37399 inv02 $PINS Y=nx37400 A=nx35888
Xix37401 inv02 $PINS Y=nx37402 A=nx35848
Xix37403 inv02 $PINS Y=nx37404 A=nx35808
Xix37405 inv02 $PINS Y=nx37406 A=nx404
Xix37411 inv02 $PINS Y=nx37412 A=nx35718
Xix37413 inv02 $PINS Y=nx37414 A=nx35718
Xix37415 inv02 $PINS Y=nx37416 A=nx35686
Xix37417 inv02 $PINS Y=nx37418 A=nx35686
Xix37419 inv02 $PINS Y=nx37420 A=camera_module_cache_address_from_DMA_0
Xix37421 inv02 $PINS Y=nx37422 A=nx37436
Xix37423 inv02 $PINS Y=nx37424 A=nx37438
Xix37425 inv02 $PINS Y=nx37426 A=nx37438
Xix37427 inv02 $PINS Y=nx37428 A=nx37438
Xix37429 inv02 $PINS Y=nx37430 A=nx37438
Xix37435 inv02 $PINS Y=nx37436 A=nx37028
Xix37437 inv02 $PINS Y=nx37438 A=nx37028
.ENDS
.GLOBAL VCC
.GLOBAL GND
